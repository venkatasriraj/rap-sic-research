options:
  parameters:
    author: venkat
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: tx_1_1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: bw
  id: variable
  parameters:
    value: '0'
  states: {}
- name: dist
  id: variable
  parameters:
    value: '[(1.0, 2)]'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 7.7e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: pktSize
  id: variable
  parameters:
    value: '32'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '40000'
  states: {}
- name: slots
  id: variable
  parameters:
    value: '3'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: totalPkts
  id: variable
  parameters:
    value: '2'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    improved_loop_filter: 'False'
    rolloff: '0.35'
    samps_per_sym: sps
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    TotalPkts: totalPkts
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import random, binascii, csv

      class blk(gr.basic_block): 

          _AccessCode = [0xAA, 0xAA, 0xAA, 0xAA]
          _filler = [0xAA, 0xAA, 0xAB, 0xAB]
          _defaultLambda = [(1.0, 2)]

          def __init__(self, userId=1, slots=20, TotalPkts=5, lambda_dist=None, activeProb=0.6, pktSize=32):  
              gr.basic_block.__init__(
                  self,
                  name='IRSA Frame Generator',   
                  in_sig=None,
                  out_sig=None
              )
              self.userId = userId
              self.TotalPkts = TotalPkts
              self.slots = slots
              self.activeProb = activeProb
              self.distribution = self._defaultLambda
              self.pktSize = pktSize
              self.frameNo = 1
              self.pktNo = 1
              self.message_port_register_in(pmt.intern("Trigger"))
              self.message_port_register_out(pmt.intern("PDU"))
              self.set_msg_handler(pmt.intern("Trigger"), self._handle_msg)

          def _handle_msg(self, msg):
              while self.pktNo <= self.TotalPkts:
                  if random.uniform(0, 1) <= self.activeProb:
                      self.frameGeneration()
                      print(f"Pkt No {self.pktNo} is transmitted in frame {self.frameNo}")
                      self.pktNo += 1
                  else:
                      print(f"Frame: {self.frameNo} is skipped")
                  self.frameNo += 1

          def genMetaData(self, metaInfo):
              meta = pmt.make_dict()
              for k, v in metaInfo.items():
                  meta = pmt.dict_add(meta, pmt.intern(f'{k}'), pmt.from_long(v))
              return meta

          def frameGeneration(self):
              # slotProb = random.uniform(0, 1.0)
              slotProb = 1.0
              degree = [d for p, d in self.distribution if p >= slotProb][0]
              # degree = 2
              # print(f"degree: {degree}, {self.pktNo}")
              slotList = random.sample(range(1, self.slots+1), degree)
              # -- Meta data generation and PDU conversion to transmit throught the chain
              data = self.packetGen(slotList)
              payload = pmt.init_u8vector(len(data), data.tolist())
              metaInfo = dict()
              for s in slotList:
                  metaInfo['slotNo'] = s
                  metaInfo['frameNo'] = self.frameNo
                  meta = self.genMetaData(metaInfo)
                  packet = pmt.cons(meta, payload)
                  self.message_port_pub(pmt.intern("PDU"), packet)

          def packetGen(self, SLOTLIST):
              """
              [Pilot Sequence[4B]| UserId[1B]| SequenceNo[1B]| FrameNo[1B]| SlotList[2 * 1B]| Payload[15B]| CRC (4B)| Filler (4B)]
              """
              seqNo = [self.pktNo & 0xFF]
              uId = [self.userId & 0xFF]
              fId = [self.frameNo & 0xFF]
              slotList = [s & 0xFF for s in SLOTLIST]
              header = np.concatenate((uId, seqNo, fId, slotList), axis=None)
              payloadSize = self.pktSize - len(header) - len(self._AccessCode) - 8
              payload = np.random.randint(0, 255, payloadSize, dtype=np.uint8)
              protected = np.concatenate((header, payload))
              # crc32_out = binascii.crc32(bytes(protected))
              # crc32 = [(crc32_out>>8)&0xFF, crc32_out & 0xFF]
              crc_val = binascii.crc32(bytes(protected)) & 0xFFFFFFFF
              crc_bytes = list(crc_val.to_bytes(4, byteorder='little'))
              packet = np.concatenate((self._AccessCode, protected, crc_bytes, self._filler), axis=None)
              return packet

          def validate_lambda(self, dist):
              if not dist:
                  raise ValueError("Distribution shouldn't be empty")
              prob = [p for p, d in dist]
              if (prob[-1] - 1.0) > 1e-6:
                  raise ValueError(f"Distribution should end with 1.0 but got {prob[-1]}")
              if prob != sorted(prob):
                  raise ValueError("Distribution is not sorted")
    activeProb: '1'
    lambda_dist: dist
    pktSize: pktSize
    slots: slots
    userId: '1'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):
          def __init__(self, fs=40e3, sps=10, pktSize=32, slots=20, silenceFrames=10):  
              gr.basic_block.__init__(
                  self,
                  name='Burst Inserter',   
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.fs = int(fs)
              self.sps = sps
              self.pktSize = pktSize
              self.slots = slots
              self.silenceFrames = silenceFrames
              self.samplesPerSlot = (pktSize * 8 ) * sps
              self.samplesPerFrame = self.samplesPerSlot * slots 
              self.pendingPkts = dict()
              self.inProgress = None
              self.pktIdx = 0
              self.inIdx = None

          def general_work(self, input_items, output_items):
              input = input_items[0]
              output = output_items[0]
              nInput = len(input)
              nOutput = len(output)
              nread = self.nitems_read(0)
              nwritten = self.nitems_written(0)

              ## --- Detection of tags and storing the input samples to insert at appropriate sample index for frame synchronization
              tags = self.get_tags_in_range(0, nread, nread+nInput)
              for tag in tags:
                  offset = tag.offset
                  relative_offset = offset - nread
                  frameNo = pmt.to_long(pmt.dict_ref(tag.value, pmt.intern("frameNo"), pmt.PMT_NIL))
                  slotNo = pmt.to_long(pmt.dict_ref(tag.value, pmt.intern("slotNo"), pmt.PMT_NIL))
                  index = (self.silenceFrames + frameNo - 1) * self.samplesPerFrame + (slotNo-1) * self.samplesPerSlot
                  to_copy = min(len(input[relative_offset:]), self.samplesPerSlot)
                  self.pendingPkts[index] = {
                      'data': input[relative_offset: relative_offset+to_copy],
                      'frameNo': frameNo,
                      'slotNo': slotNo
                  }
                  if to_copy != self.samplesPerSlot:
                      self.inIdx = dict()
                      self.inIdx['dataIdx'] = to_copy
                      self.inIdx['index'] = index
                  else:
                      self.inIdx = None
              if self.inIdx != None:
                  dataIdx = self.inIdx['dataIdx']
                  index = self.inIdx['index']
                  if dataIdx <= self.samplesPerSlot:
                      to_copy = min(self.samplesPerSlot-dataIdx, nInput)
                      updateData = self.pendingPkts[index]['data']
                      self.pendingPkts[index]['data'] = np.concatenate((updateData, input[:to_copy]), axis=None)
                      dataIdx += to_copy
                  if dataIdx == self.samplesPerSlot:
                      self.inIdx = None
                  else:
                      self.inIdx['dataIdx'] = dataIdx
              tagIdx = sorted(self.pendingPkts.keys())
              indicesSelected = [idx for idx in tagIdx if idx >= nwritten and idx < nwritten+nOutput]
              print(f"Indices Selected: {indicesSelected}, {nwritten}, {nwritten+nOutput}, {tagIdx}")
              buffer = np.zeros(nOutput, dtype=np.complex64)
              if self.inProgress is not None:
                  to_copy = min(len(self.inProgress[self.pktIdx:]), nOutput)
                  buffer[:to_copy] = self.inProgress[self.pktIdx:self.pktIdx+to_copy]
                  self.pktIdx += to_copy
              if len(indicesSelected) == 0:
                  output[:] = buffer
              else:
                  for idx in indicesSelected:
                      relative_offset = idx - nwritten
                      self.inProgress = self.pendingPkts[idx]['data']
                      to_copy = min(self.samplesPerSlot, len(buffer[relative_offset:]))
                      buffer[relative_offset: relative_offset+to_copy] = self.inProgress[:to_copy]
                      self.pktIdx = to_copy
                      del self.pendingPkts[idx]
                  output[:] = buffer    
              if self.pktIdx == self.samplesPerSlot:
                  self.pktIdx = 0
                  self.inProgress = None
              return len(output_items[0])
    fs: samp_rate
    pktSize: pktSize
    silenceFrames: '1'
    slots: slots
    sps: sps
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      from collections import deque

      class blk(gr.sync_block):  

          def __init__(self): 
              gr.sync_block.__init__(
                  self,
                  name='EPB: PDU to Tagged Stream', 
                  in_sig=None,
                  out_sig=[np.uint8]
              )
              self.message_port_register_in(pmt.intern("PDU_in"))
              self.set_msg_handler(pmt.intern("PDU_in"), self._handle_msg)
              self.pkts = deque()
              self.inProgress = None
              self.pktIdx = 0

          def _handle_msg(self, msg):
              meta = pmt.car(msg)
              payload = pmt.cdr(msg)
              data = np.array(pmt.u8vector_elements(payload), dtype=np.uint8)
              frameNo = pmt.to_long(
                          pmt.dict_ref(meta, pmt.intern("frameNo"), pmt.PMT_NIL)
              )
              slotNo = pmt.to_long(
                          pmt.dict_ref(meta, pmt.intern("slotNo"), pmt.PMT_NIL)
              )
              self.pkts.append((data, frameNo, slotNo))

          def work(self, input_items, output_items):
              out = output_items[0]
              produced = 0
              nOutput = len(out)
              while produced < nOutput:
                  #  --- New Packet
                  if self.inProgress is None:
                      if not self.pkts:
                          break
                      self.inProgress = self.pkts.popleft()
                      self.pktIdx = 0
                      data, frameNo, slotNo = self.inProgress

                      tag_offset = self.nitems_written(0) + produced

                      value = pmt.make_dict()
                      value = pmt.dict_add(value, pmt.intern("frameNo"), pmt.from_long(frameNo))
                      value = pmt.dict_add(value, pmt.intern("slotNo"), pmt.from_long(slotNo))
                      value = pmt.dict_add(value, pmt.intern("pktLen"), pmt.from_long(len(data)))
                      self.add_item_tag(0, tag_offset, pmt.intern("pktInfo"), value)
                      # self.add_item_tag(0, tag_offset, pmt.intern("frameNo"), pmt.from_long(frameNo))
                      # self.add_item_tag(0, tag_offset, pmt.intern("slotNo"), pmt.from_long(slotNo))
                      # self.add_item_tag(0, tag_offset, pmt.intern("pktLen"), pmt.from_long(len(data)))
                  ##  ---- Current Packet    
                  data, frameNo, slotNo = self.inProgress
                  to_copy = min(len(data[self.pktIdx:]), nOutput-produced)

                  out[produced: produced+to_copy] = data[self.pktIdx: self.pktIdx+to_copy]
                  self.pktIdx += to_copy
                  produced += to_copy

                  if self.pktIdx == len(data):
                      self.pktIdx = 0
                      self.inProgress = None
              return produced
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*samp_rate
    samp_rate: samp_rate
    sym_rate: '4000'
    type: ccc
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Tx_out
  states: {}

connections:
- [blocks_message_strobe_0, strobe, epy_block_0, Trigger]
- [blocks_throttle2_0, '0', virtual_sink_0, '0']
- [digital_constellation_modulator_0, '0', epy_block_1, '0']
- [epy_block_0, PDU, epy_block_2, PDU_in]
- [epy_block_1, '0', fft_filter_xxx_0, '0']
- [epy_block_2, '0', digital_constellation_modulator_0, '0']
- [fft_filter_xxx_0, '0', blocks_throttle2_0, '0']
- [fft_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [filter_fft_rrc_filter_0, '0', digital_fll_band_edge_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
