options:
  parameters:
    author: venkat
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: tx_1_1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import csv
      import pmt
      import random

      class blk(gr.basic_block): 

          _AccessCode = [0xAA, 0xAA, 0xAA, 0xAA]
          _filler = [0xAA, 0xAA, 0xAB, 0xAB]
          _defaultLambda = [(1.0, 2)]
          _packetSize = 24

          def __init__(self, userId=1, slots=20, packets=5, lambda_dist=None, activeProb=0.6):  
              gr.sync_block.__init__(
                  self,
                  name='IRSA Frame Generator',   
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("out"), self._handle_msg())
              self.userId = userId
              self.packets = packets
              self.slots = slots
              self.frames = 0
              self.sequenceNo = 0
              self.activeProb = activeProb
              # self.distribution = lambda_dist if self.validate_lambda(lambda_dist) else self._defaultLambda
              self.distribution = self._defaultLambda

          def _handle_msg(self):
              print("Start of this Block")

          def frameGeneration(self):
              self.frames += 1
              if random.uniform(0, 1) < self.activeProb:
                  print("Frame Skipped")
              else:
                  print("Packet will be transmitted")
                  slotProb = random.uniform(0, 1.0)
                  degree = [p for p, d in self.distribution if p > slotProb][0]
                  slotList = random.sample(range(1, self.slots+1), degree)
                  packet = self.packetGen(slotList)
              return None

          def packetGen(self, SLOTLIST):
              """
              [Pilot Sequence[4B]| UserId[1B]| SequenceNo[1B]| FrameNo[1B]| SlotList[2 * 1B]| Payload[15B]| ]
              """
              if self.sequenceNo >= self.packets:
                  return None
              self.sequenceNo += 1
              seqNo = self.sequenceNo & 0xFF
              uId = self.userId & 0xFF
              fId = self.frames & 0xFF
              slotList = [s & 0xFF for s in SLOTLIST]
              header = np.concatenate((self._AccessCode, uId, seqNo, fId, slotList), axis=None)
              payloadSize = self._packetSize - len(header)
              payload = np.random.randint(0, 255, payloadSize)
              packet = np.concatenate((header, payload))
              return packet

          def validate_lambda(self, dist):
              if not dist:
                  raise ValueError("Distribution shouldn't be empty")
              prob = [p for p, d in dist]
              if (prob[-1] - 1.0) > 1e-6:
                  raise ValueError(f"Distribution should end with 1.0 but got {prob[-1]}")
              if prob != sorted(prob):
                  raise ValueError("Distribution is not sorted")
    frames: '2'
    slots: '20'
    userId: '1'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self, example_param=1.0):  
              gr.sync_block.__init__(
                  self,
                  name='Burst Inserter',   
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.example_param = example_param

          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: '1.0'
  states: {}

connections:
- [blocks_throttle2_0, '0', epy_block_1, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
