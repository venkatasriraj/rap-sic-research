options:
  parameters:
    author: venka
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: TX_c
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: N_Slots
  id: variable
  parameters:
    value: '5'
  states: {}
- name: T_slot
  id: variable
  parameters:
    value: ((packet_size+4)*8*sps)/(bps*samp_rate)
  states: {}
- name: bps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: bw
  id: variable
  parameters:
    value: (1+excess_bw)*(samp_rate//sps)
  states: {}
- name: dist
  id: variable
  parameters:
    value: '[(2, 0.60), (3, 1.00)]'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Offset
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: initial_delay
  id: variable
  parameters:
    value: '0'
  states: {}
- name: low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: (bw//2)+5e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    label: Noise Voltage
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.0'
  states: {}
- name: packet_size
  id: variable
  parameters:
    value: '96'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0 + 0.0j, ]'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '28'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    label: Timing Offset
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.000'
  states: {}
- name: user_id1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: user_id2
  id: variable
  parameters:
    value: '2'
  states: {}
- name: user_id3
  id: variable
  parameters:
    value: '3'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: 40e3
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_0_0_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_float_to_complex_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0_0_0
  id: blocks_repeat
  parameters:
    interp: 8*sps
    type: float
  states: {}
- name: blocks_repeat_0_0_0_0
  id: blocks_repeat
  parameters:
    interp: 8*sps
    type: float
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_1_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: taps
  states: {}
- name: digital_constellation_modulator_0_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    N_slots: N_Slots
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import random
      import time
      import threading
      import csv


      # ─────────────────────────────────────────────────────────────────────────────
      #  IRSA_Packet_Generator
      #  Embedded Python Block for GNU Radio
      #
      #  Listens on 'frame_trigger' for a GNU Radio Message Strobe pulse.
      #  On each pulse it runs the IRSA algorithm for one frame:
      #    1.  Gate check: if all n packets are done → silently ignore the trigger.
      #    2.  Random access decision: flip a biased coin (tx_probability).
      #        If tails → stay silent for this entire frame.
      #    3.  Draw degree d from Lambda_Dist (CDF form).
      #    4.  Select d unique random slots from [1 .. N_slots].
      #    5.  Build d identical packet copies (same payload, different slot headers).
      #    6.  Schedule each copy at T_frame + (slot-1)*slot_dur.
      #    7.  Increment packets_sent.  When packets_sent == total_packets,
      #        publish a 'done' PMT message so the flowgraph can self-terminate.
      #
      #  Packet byte layout (fixed-size header so the RX side can parse blindly):
      #
      #    Offset  Size  Field
      #    ──────  ────  ─────────────────────────────────────────────────────────
      #      0      4    access_code         [0xE1, 0x5A, 0xE8, 0x93]
      #      4      2    user_id             uint16 big-endian
      #      6      2    frame_seq           uint16 big-endian
      #      8      1    degree  (d)         uint8
      #      9      1    this_slot           uint8  (1-indexed slot of this copy)
      #     10      1    seed_lo             uint8  lower byte of per-frame RNG seed
      #     11      1    seed_hi             uint8  upper byte of per-frame RNG seed
      #     12      MAX_DEGREE  slot_list   d entries, zero-padded to MAX_DEGREE bytes
      #     12+MAX_DEGREE  ...  random_data fills rest of packet_size
      #     last 4       filler             [0xE1, 0x5A, 0xE8, 0xAA]
      #
      #  Notes
      #  ─────
      #  • All d copies share the SAME random_data.  This is mandatory for SIC:
      #    the receiver must be able to subtract bit-exact replicas.
      #  • A per-frame 16-bit seed is embedded so the receiver can independently
      #    regenerate and verify the random payload (optional but useful for SIC).
      #  • Slot timing uses threading.Timer against the wall clock captured the
      #    instant the frame_trigger message arrives.  Jitter is bounded by OS
      #    scheduling (~1–5 ms), which is acceptable for a software simulation.
      #    If you need tighter alignment, replace Timer with a busy-wait loop.
      #  • This block is purely message-driven (no streaming ports), so it must
      #    be gr.basic_block — NOT gr.sync_block.
      #
      #  GNU Radio Companion wiring
      #  ──────────────────────────
      #  Message Strobe  →  frame_trigger   (this block)
      #                      pdu_out        →  Async CRC32  →  Protocol Formatter
      #                                                      →  PDU to Tagged Stream
      #                                                      →  (rest of TX chain)
      # ─────────────────────────────────────────────────────────────────────────────

      # Sentinel: used to pad the slot_list field for unused entries
      _SLOT_PAD = 0x00

      class IRSA_Packet_Generator(gr.basic_block):

          # ── Default Lambda distribution (IRSA literature optimum) ─────────────
          #   Lambda = 0.5*x^2 + 0.28*x^3 + 0.22*x^8
          #   Stored as cumulative CDF: [(degree, cum_prob), ...]
          _DEFAULT_LAMBDA = [
              (2, 0.50),
              (3, 0.78),
              (8, 1.00),
          ]

          # ── Fixed access code (must match Correlate Access Code block at RX) ──
          _ACCESS_CODE = [0xE1, 0x5A, 0xE8, 0x93]
          # ── Filler appended at tail (helps framing / debugging) ───────────────
          _FILLER      = [0xE1, 0x5A, 0xE8, 0xAA]

          # Maximum degree supported by the fixed header layout
          MAX_DEGREE = 16

          def __init__(
              self,
              N_slots        = 100,
              slot_duration  = 0.04437,   # seconds — must match actual pkt air-time
              lambda_dist    = None,      # CDF list [(degree, cum_prob),...] or None
              user_id        = 1,
              packet_size    = 100,       # total bytes per copy (incl. header+filler)
              total_packets  = 10,        # how many distinct packets this user will send
              tx_probability = 0.7,       # P(attempt to transmit | frame trigger received)
              # log_file       = "irsa_tx.csv",
              initial_delay  = 2.0,       # seconds — wait before accepting first frame
          ):
              gr.basic_block.__init__(
                  self,
                  name    = "irsa_packet_generator",
                  in_sig  = None,
                  out_sig = None,
              )

              # ── Message ports ─────────────────────────────────────────────────
              self.message_port_register_in(pmt.intern('frame_trigger'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              # 'done' fires once when the final packet has been scheduled
              self.message_port_register_out(pmt.intern('done'))
              self.set_msg_handler(pmt.intern('frame_trigger'), self._on_frame_trigger)

              # ── Parameters ────────────────────────────────────────────────────
              self.N_slots        = int(N_slots)
              self.slot_duration  = float(slot_duration)
              self.user_id        = int(user_id) & 0xFFFF
              self.packet_size    = int(packet_size)
              self.total_packets  = int(total_packets)
              self.log_file       = f"irsa_tx{int(user_id)}.csv"
              self.initial_delay  = float(initial_delay)

              if not (0.0 < tx_probability <= 1.0):
                  raise ValueError(
                      f"tx_probability must be in (0, 1], got {tx_probability}"
                  )
              self.tx_probability = float(tx_probability)

              # ── Lambda distribution (validate + store) ────────────────────────
              dist = lambda_dist if lambda_dist is not None else self._DEFAULT_LAMBDA
              self._validate_lambda(dist)
              self.lambda_dist = dist

              # ── Header size sanity check ──────────────────────────────────────
              # access_code(4) + user_id(2) + frame_seq(2) + degree(1) +
              # this_slot(1) + seed_lo(1) + seed_hi(1) + slot_list(MAX_DEGREE) + filler(4)
              self._fixed_header_bytes = (
                  len(self._ACCESS_CODE) + 2 + 2 + 1 + 1 + 1 + 1 +
                  self.MAX_DEGREE + len(self._FILLER)
              )
              if packet_size <= self._fixed_header_bytes:
                  raise ValueError(
                      f"packet_size ({packet_size}) must be > {self._fixed_header_bytes} "
                      f"to accommodate the fixed IRSA header."
                  )

              # ── Runtime state ──────────────────────────────────────────────────
              self._frame_seq      = 0
              self._packets_sent   = 0    # counts packets committed for transmission
              self._frames_skipped = 0    # frames where coin flip said "stay silent"
              self._timers         = []
              self._lock           = threading.Lock()
              self._ready          = False   # True after initial_delay has passed

              # ── CSV log ────────────────────────────────────────────────────────
              with open(self.log_file, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'packet_id', 'frame_seq', 'user_id', 'degree',
                      'chosen_slots', 'this_slot', 'wall_clock_tx', 'rng_seed',
                      'decision',   # 'TX' or 'SKIP'
                  ])

              # ── Delayed-ready thread ───────────────────────────────────────────
              threading.Thread(
                  target  = self._warmup_wait,
                  daemon  = True,
                  name    = f"irsa_tx{user_id}_warmup",
              ).start()

              print(
                  f"[IRSA_TX{self.user_id}] Init: N_slots={N_slots}, "
                  f"slot_dur={slot_duration*1e3:.2f} ms, "
                  f"frame_dur={N_slots * slot_duration:.3f} s, "
                  f"total_packets={total_packets}, "
                  f"tx_prob={tx_probability:.2f}, "
                  f"lambda={dist}"
              )

          # ── Helpers ───────────────────────────────────────────────────────────

          @staticmethod
          def _validate_lambda(dist):
              """Ensure the CDF list is sorted, non-empty, and ends at 1.0."""
              if not dist:
                  raise ValueError("lambda_dist must be a non-empty list.")
              probs = [p for _, p in dist]
              if abs(probs[-1] - 1.0) > 1e-6:
                  raise ValueError(f"lambda_dist CDF must end at 1.0, got {probs[-1]}")
              if probs != sorted(probs):
                  raise ValueError("lambda_dist CDF probabilities must be non-decreasing.")

          def _warmup_wait(self):
              time.sleep(self.initial_delay)
              self._ready = True
              print(f"[IRSA_TX{self.user_id}] Ready — accepting frame triggers.")

          def _draw_degree(self) -> int:
              """Sample degree d from the Lambda CDF."""
              r = random.random()
              for degree, cum_prob in self.lambda_dist:
                  if r <= cum_prob:
                      return int(degree)
              return int(self.lambda_dist[-1][0])   # numerical safety fallback

          def _build_copy(
              self,
              frame_seq   : int,
              degree      : int,
              this_slot   : int,
              slot_list   : list,
              rng_seed    : int,
              random_data : list,
          ) -> list:
              """
              Assemble one packet copy for a specific slot.

              All copies within a frame share 'random_data' and 'rng_seed' so the
              receiver can replicate (and cancel) the payload during SIC.
              Only 'this_slot' differs between copies.
              """
              # ── Fixed header fields ────────────────────────────────────────────
              uid_bytes  = [(self.user_id >> 8) & 0xFF,  self.user_id & 0xFF]
              seq_bytes  = [(frame_seq   >> 8) & 0xFF,   frame_seq    & 0xFF]
              deg_byte   = [degree & 0xFF]
              slot_byte  = [this_slot & 0xFF]
              seed_bytes = [rng_seed & 0xFF, (rng_seed >> 8) & 0xFF]   # LE u16

              # Slot list: d entries, zero-padded to MAX_DEGREE
              slot_field  = [s & 0xFF for s in slot_list]
              slot_field += [_SLOT_PAD] * (self.MAX_DEGREE - len(slot_field))

              header = (
                  self._ACCESS_CODE +
                  uid_bytes  +
                  seq_bytes  +
                  deg_byte   +
                  slot_byte  +
                  seed_bytes +
                  slot_field
              )

              # header + random_data + filler = packet_size  (enforced at init time)
              return header + random_data + self._FILLER

          # ── Slot emission ──────────────────────────────────────────────────────

          def _emit_slot(
              self,
              packet_id   : int,
              frame_seq   : int,
              degree      : int,
              this_slot   : int,
              slot_list   : list,
              rng_seed    : int,
              random_data : list,
          ):
              """
              Timer callback: build the packet for this slot and publish it as a PDU.
              Runs in a daemon thread — keep it short and thread-safe.
              """
              data = self._build_copy(
                  frame_seq, degree, this_slot, slot_list, rng_seed, random_data
              )

              # ── PMT metadata ──────────────────────────────────────────────────
              meta = pmt.make_dict()
              meta = pmt.dict_add(meta, pmt.intern('user_id'),   pmt.from_long(self.user_id))
              meta = pmt.dict_add(meta, pmt.intern('frame_seq'), pmt.from_long(frame_seq))
              meta = pmt.dict_add(meta, pmt.intern('packet_id'), pmt.from_long(packet_id))
              meta = pmt.dict_add(meta, pmt.intern('degree'),    pmt.from_long(degree))
              meta = pmt.dict_add(meta, pmt.intern('this_slot'), pmt.from_long(this_slot))
              # 'packet_num' consumed by Protocol Formatter / Packet Header Generator
              meta = pmt.dict_add(meta, pmt.intern('packet_num'),pmt.from_long(frame_seq))

              pdu = pmt.cons(meta, pmt.init_u8vector(len(data), data))
              self.message_port_pub(pmt.intern('pdu_out'), pdu)

              # ── CSV log ────────────────────────────────────────────────────────
              ts = (time.strftime('%Y-%m-%d %H:%M:%S') +
                    f".{int((time.time() % 1) * 1000):03d}")
              with open(self.log_file, 'a', newline='') as f:
                  csv.writer(f).writerow([
                      packet_id, frame_seq, self.user_id, degree,
                      slot_list, this_slot, ts, f"0x{rng_seed:04X}", 'TX',
                  ])

              print(
                  f"[IRSA_TX{self.user_id}] "
                  f"Pkt={packet_id:03d}/{self.total_packets}  "
                  f"Frame={frame_seq:04d}  Slot={this_slot:03d}/{self.N_slots}  "
                  f"d={degree}  copies@{slot_list}  seed=0x{rng_seed:04X}"
              )

          # ── Frame trigger handler ──────────────────────────────────────────────

          def _on_frame_trigger(self, msg):
              """
              GNU Radio calls this in the scheduler thread when a strobe fires.
              Must return quickly — all slot transmissions are dispatched to
              threading.Timer callbacks so we don't block the scheduler.

              Decision flow
              ─────────────
              1. Warmup gate  — ignore if still in initial_delay period.
              2. Budget gate  — ignore if all total_packets already scheduled.
              3. Coin flip    — with probability (1 - tx_probability), stay silent
                                for this frame and log it as SKIP.
              4. Run IRSA     — draw degree, pick slots, schedule timers.
              5. Increment    — bump _packets_sent; if now == total_packets, fire 'done'.
              """
              if not self._ready:
                  print(f"[IRSA_TX{self.user_id}] Frame trigger ignored — still in warmup.")
                  return

              # ── Gate 1: budget exhausted ───────────────────────────────────────
              with self._lock:
                  if self._packets_sent >= self.total_packets:
                      # Already done — silently absorb any late strobe pulses
                      return
                  # Tentatively claim this frame's packet slot to avoid a race
                  # condition when timers from the previous frame are still firing.
                  # We commit unconditionally here; the coin flip below can un-claim
                  # it by decrementing if we decide to skip.
                  # Actually, we do the coin flip BEFORE claiming so the budget is
                  # only consumed on genuine transmit decisions.
                  pass  # (budget check done; proceed to coin flip)

              # ── Gate 2: random access decision ────────────────────────────────
              # Coin flip is OUTSIDE the lock — it's cheap and avoids holding the
              # lock during the print/log on a SKIP decision.
              if random.random() > self.tx_probability:
                  with self._lock:
                      self._frames_skipped += 1
                      skipped = self._frames_skipped
                      sent    = self._packets_sent
                      remaining = self.total_packets - sent

                  frame_seq = self._frame_seq
                  self._frame_seq = (self._frame_seq + 1) & 0xFFFF

                  print(
                      f"[IRSA_TX{self.user_id}] "
                      f"Frame={frame_seq:04d}  SKIP (coin)  "
                      f"remaining={remaining}/{self.total_packets}  "
                      f"total_skips={skipped}"
                  )
                  # Log the skip so we can audit TX efficiency later
                  ts = (time.strftime('%Y-%m-%d %H:%M:%S') +
                        f".{int((time.time() % 1) * 1000):03d}")
                  with open(self.log_file, 'a', newline='') as f:
                      csv.writer(f).writerow([
                          '-', frame_seq, self.user_id, '-',
                          '-', '-', ts, '-', 'SKIP',
                      ])
                  return

              # ── Claim the packet budget slot ───────────────────────────────────
              with self._lock:
                  packet_id = self._packets_sent + 1      # 1-indexed for readability
                  self._packets_sent += 1
                  is_last = (self._packets_sent >= self.total_packets)

              frame_seq = self._frame_seq
              self._frame_seq = (self._frame_seq + 1) & 0xFFFF

              # ── IRSA Algorithm ─────────────────────────────────────────────────
              # Step 1: Draw degree
              degree = self._draw_degree()

              # Step 2: Select d unique slots (1-indexed)
              chosen_slots = sorted(random.sample(range(1, self.N_slots + 1), degree))

              # Step 3: Generate shared payload ONCE — identical across all d copies
              # rng_seed    = random.randint(0, 0xFFFF)
              rng_seed    = (self.user_id * 31 + frame_seq) & 0xFFFF
              payload_len = self.packet_size - self._fixed_header_bytes
              rng         = random.Random(rng_seed)   # seeded sub-RNG for reproducibility
              random_data = [rng.randint(0, 255) for _ in range(payload_len)]

              print(
                  f"[IRSA_TX{self.user_id}] "
                  f"Pkt={packet_id:03d}/{self.total_packets}  "
                  f"Frame={frame_seq:04d}  d={degree}  slots={chosen_slots}"
                  + ("  <- LAST PACKET" if is_last else "")
              )

              # ── Step 4: Schedule one PDU per chosen slot ───────────────────────
              t_frame = time.time()   # wall-clock anchor for this frame

              with self._lock:
                  # Clean up completed timers from previous frames
                  self._timers = [t for t in self._timers if t.is_alive()]

                  for slot in chosen_slots:
                      delay = (slot - 1) * self.slot_duration

                      t = threading.Timer(
                          interval = delay,
                          function = self._emit_slot,
                          args     = (packet_id, frame_seq, degree, slot,
                                      chosen_slots, rng_seed, random_data),
                      )
                      t.daemon = True
                      t.start()
                      self._timers.append(t)

              # ── Step 5: Fire 'done' when budget is exhausted ───────────────────
              if is_last:
                  # Delay the 'done' signal until after the last slot timer has had
                  # time to fire, so downstream blocks aren't torn down prematurely.
                  last_slot_delay = (max(chosen_slots) - 1) * self.slot_duration + 0.5
                  done_timer = threading.Timer(
                      interval = last_slot_delay,
                      function = self._signal_done,
                  )
                  done_timer.daemon = True
                  done_timer.start()

          # ── Lifecycle helpers ──────────────────────────────────────────────────

          def _signal_done(self):
              """
              Fires once, after the last slot timer has had time to emit.
              Publishes a PMT symbol on the 'done' port so the flowgraph can
              self-terminate (e.g. connect to a Message Debug or a custom stopper).
              """
              msg = pmt.cons(
                  pmt.intern('done'),
                  pmt.from_long(self.user_id),
              )
              self.message_port_pub(pmt.intern('done'), msg)
              print(
                  f"[IRSA_TX{self.user_id}] DONE — "
                  f"all {self.total_packets} packets scheduled, "
                  f"frames_skipped={self._frames_skipped}"
              )

          def stop(self):
              """Cancel all pending slot timers on flowgraph stop."""
              with self._lock:
                  for t in self._timers:
                      t.cancel()
                  self._timers.clear()
              print(
                  f"[IRSA_TX{self.user_id}] Stopped. "
                  f"packets_sent={self._packets_sent}/{self.total_packets}  "
                  f"frames_processed={self._frame_seq}  "
                  f"frames_skipped={self._frames_skipped}"
              )
              return True
    initial_delay: initial_delay
    lambda_dist: dist
    packet_size: packet_size
    slot_duration: T_slot
    total_packets: '1'
    tx_probability: '1'
    user_id: user_id1
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    N_slots: N_Slots
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import random
      import time
      import threading
      import csv


      # ─────────────────────────────────────────────────────────────────────────────
      #  IRSA_Packet_Generator
      #  Embedded Python Block for GNU Radio
      #
      #  Listens on 'frame_trigger' for a GNU Radio Message Strobe pulse.
      #  On each pulse it runs the IRSA algorithm for one frame:
      #    1.  Gate check: if all n packets are done → silently ignore the trigger.
      #    2.  Random access decision: flip a biased coin (tx_probability).
      #        If tails → stay silent for this entire frame.
      #    3.  Draw degree d from Lambda_Dist (CDF form).
      #    4.  Select d unique random slots from [1 .. N_slots].
      #    5.  Build d identical packet copies (same payload, different slot headers).
      #    6.  Schedule each copy at T_frame + (slot-1)*slot_dur.
      #    7.  Increment packets_sent.  When packets_sent == total_packets,
      #        publish a 'done' PMT message so the flowgraph can self-terminate.
      #
      #  Packet byte layout (fixed-size header so the RX side can parse blindly):
      #
      #    Offset  Size  Field
      #    ──────  ────  ─────────────────────────────────────────────────────────
      #      0      4    access_code         [0xE1, 0x5A, 0xE8, 0x93]
      #      4      2    user_id             uint16 big-endian
      #      6      2    frame_seq           uint16 big-endian
      #      8      1    degree  (d)         uint8
      #      9      1    this_slot           uint8  (1-indexed slot of this copy)
      #     10      1    seed_lo             uint8  lower byte of per-frame RNG seed
      #     11      1    seed_hi             uint8  upper byte of per-frame RNG seed
      #     12      MAX_DEGREE  slot_list   d entries, zero-padded to MAX_DEGREE bytes
      #     12+MAX_DEGREE  ...  random_data fills rest of packet_size
      #     last 4       filler             [0xE1, 0x5A, 0xE8, 0xAA]
      #
      #  Notes
      #  ─────
      #  • All d copies share the SAME random_data.  This is mandatory for SIC:
      #    the receiver must be able to subtract bit-exact replicas.
      #  • A per-frame 16-bit seed is embedded so the receiver can independently
      #    regenerate and verify the random payload (optional but useful for SIC).
      #  • Slot timing uses threading.Timer against the wall clock captured the
      #    instant the frame_trigger message arrives.  Jitter is bounded by OS
      #    scheduling (~1–5 ms), which is acceptable for a software simulation.
      #    If you need tighter alignment, replace Timer with a busy-wait loop.
      #  • This block is purely message-driven (no streaming ports), so it must
      #    be gr.basic_block — NOT gr.sync_block.
      #
      #  GNU Radio Companion wiring
      #  ──────────────────────────
      #  Message Strobe  →  frame_trigger   (this block)
      #                      pdu_out        →  Async CRC32  →  Protocol Formatter
      #                                                      →  PDU to Tagged Stream
      #                                                      →  (rest of TX chain)
      # ─────────────────────────────────────────────────────────────────────────────

      # Sentinel: used to pad the slot_list field for unused entries
      _SLOT_PAD = 0x00

      class IRSA_Packet_Generator(gr.basic_block):

          # ── Default Lambda distribution (IRSA literature optimum) ─────────────
          #   Lambda = 0.5*x^2 + 0.28*x^3 + 0.22*x^8
          #   Stored as cumulative CDF: [(degree, cum_prob), ...]
          _DEFAULT_LAMBDA = [
              (2, 0.50),
              (3, 0.78),
              (8, 1.00),
          ]

          # ── Fixed access code (must match Correlate Access Code block at RX) ──
          _ACCESS_CODE = [0xE1, 0x5A, 0xE8, 0x93]
          # ── Filler appended at tail (helps framing / debugging) ───────────────
          _FILLER      = [0xE1, 0x5A, 0xE8, 0xAA]

          # Maximum degree supported by the fixed header layout
          MAX_DEGREE = 16

          def __init__(
              self,
              N_slots        = 100,
              slot_duration  = 0.04437,   # seconds — must match actual pkt air-time
              lambda_dist    = None,      # CDF list [(degree, cum_prob),...] or None
              user_id        = 1,
              packet_size    = 100,       # total bytes per copy (incl. header+filler)
              total_packets  = 10,        # how many distinct packets this user will send
              tx_probability = 0.7,       # P(attempt to transmit | frame trigger received)
              # log_file       = "irsa_tx.csv",
              initial_delay  = 2.0,       # seconds — wait before accepting first frame
          ):
              gr.basic_block.__init__(
                  self,
                  name    = "irsa_packet_generator",
                  in_sig  = None,
                  out_sig = None,
              )

              # ── Message ports ─────────────────────────────────────────────────
              self.message_port_register_in(pmt.intern('frame_trigger'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              # 'done' fires once when the final packet has been scheduled
              self.message_port_register_out(pmt.intern('done'))
              self.set_msg_handler(pmt.intern('frame_trigger'), self._on_frame_trigger)

              # ── Parameters ────────────────────────────────────────────────────
              self.N_slots        = int(N_slots)
              self.slot_duration  = float(slot_duration)
              self.user_id        = int(user_id) & 0xFFFF
              self.packet_size    = int(packet_size)
              self.total_packets  = int(total_packets)
              self.log_file       = f"irsa_tx{int(user_id)}.csv"
              self.initial_delay  = float(initial_delay)

              if not (0.0 < tx_probability <= 1.0):
                  raise ValueError(
                      f"tx_probability must be in (0, 1], got {tx_probability}"
                  )
              self.tx_probability = float(tx_probability)

              # ── Lambda distribution (validate + store) ────────────────────────
              dist = lambda_dist if lambda_dist is not None else self._DEFAULT_LAMBDA
              self._validate_lambda(dist)
              self.lambda_dist = dist

              # ── Header size sanity check ──────────────────────────────────────
              # access_code(4) + user_id(2) + frame_seq(2) + degree(1) +
              # this_slot(1) + seed_lo(1) + seed_hi(1) + slot_list(MAX_DEGREE) + filler(4)
              self._fixed_header_bytes = (
                  len(self._ACCESS_CODE) + 2 + 2 + 1 + 1 + 1 + 1 +
                  self.MAX_DEGREE + len(self._FILLER)
              )
              if packet_size <= self._fixed_header_bytes:
                  raise ValueError(
                      f"packet_size ({packet_size}) must be > {self._fixed_header_bytes} "
                      f"to accommodate the fixed IRSA header."
                  )

              # ── Runtime state ──────────────────────────────────────────────────
              self._frame_seq      = 0
              self._packets_sent   = 0    # counts packets committed for transmission
              self._frames_skipped = 0    # frames where coin flip said "stay silent"
              self._timers         = []
              self._lock           = threading.Lock()
              self._ready          = False   # True after initial_delay has passed

              # ── CSV log ────────────────────────────────────────────────────────
              with open(self.log_file, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'packet_id', 'frame_seq', 'user_id', 'degree',
                      'chosen_slots', 'this_slot', 'wall_clock_tx', 'rng_seed',
                      'decision',   # 'TX' or 'SKIP'
                  ])

              # ── Delayed-ready thread ───────────────────────────────────────────
              threading.Thread(
                  target  = self._warmup_wait,
                  daemon  = True,
                  name    = f"irsa_tx{user_id}_warmup",
              ).start()

              print(
                  f"[IRSA_TX{self.user_id}] Init: N_slots={N_slots}, "
                  f"slot_dur={slot_duration*1e3:.2f} ms, "
                  f"frame_dur={N_slots * slot_duration:.3f} s, "
                  f"total_packets={total_packets}, "
                  f"tx_prob={tx_probability:.2f}, "
                  f"lambda={dist}"
              )

          # ── Helpers ───────────────────────────────────────────────────────────

          @staticmethod
          def _validate_lambda(dist):
              """Ensure the CDF list is sorted, non-empty, and ends at 1.0."""
              if not dist:
                  raise ValueError("lambda_dist must be a non-empty list.")
              probs = [p for _, p in dist]
              if abs(probs[-1] - 1.0) > 1e-6:
                  raise ValueError(f"lambda_dist CDF must end at 1.0, got {probs[-1]}")
              if probs != sorted(probs):
                  raise ValueError("lambda_dist CDF probabilities must be non-decreasing.")

          def _warmup_wait(self):
              time.sleep(self.initial_delay)
              self._ready = True
              print(f"[IRSA_TX{self.user_id}] Ready — accepting frame triggers.")

          def _draw_degree(self) -> int:
              """Sample degree d from the Lambda CDF."""
              r = random.random()
              for degree, cum_prob in self.lambda_dist:
                  if r <= cum_prob:
                      return int(degree)
              return int(self.lambda_dist[-1][0])   # numerical safety fallback

          def _build_copy(
              self,
              frame_seq   : int,
              degree      : int,
              this_slot   : int,
              slot_list   : list,
              rng_seed    : int,
              random_data : list,
          ) -> list:
              """
              Assemble one packet copy for a specific slot.

              All copies within a frame share 'random_data' and 'rng_seed' so the
              receiver can replicate (and cancel) the payload during SIC.
              Only 'this_slot' differs between copies.
              """
              # ── Fixed header fields ────────────────────────────────────────────
              uid_bytes  = [(self.user_id >> 8) & 0xFF,  self.user_id & 0xFF]
              seq_bytes  = [(frame_seq   >> 8) & 0xFF,   frame_seq    & 0xFF]
              deg_byte   = [degree & 0xFF]
              slot_byte  = [this_slot & 0xFF]
              seed_bytes = [rng_seed & 0xFF, (rng_seed >> 8) & 0xFF]   # LE u16

              # Slot list: d entries, zero-padded to MAX_DEGREE
              slot_field  = [s & 0xFF for s in slot_list]
              slot_field += [_SLOT_PAD] * (self.MAX_DEGREE - len(slot_field))

              header = (
                  self._ACCESS_CODE +
                  uid_bytes  +
                  seq_bytes  +
                  deg_byte   +
                  slot_byte  +
                  seed_bytes +
                  slot_field
              )

              # header + random_data + filler = packet_size  (enforced at init time)
              return header + random_data + self._FILLER

          # ── Slot emission ──────────────────────────────────────────────────────

          def _emit_slot(
              self,
              packet_id   : int,
              frame_seq   : int,
              degree      : int,
              this_slot   : int,
              slot_list   : list,
              rng_seed    : int,
              random_data : list,
          ):
              """
              Timer callback: build the packet for this slot and publish it as a PDU.
              Runs in a daemon thread — keep it short and thread-safe.
              """
              data = self._build_copy(
                  frame_seq, degree, this_slot, slot_list, rng_seed, random_data
              )

              # ── PMT metadata ──────────────────────────────────────────────────
              meta = pmt.make_dict()
              meta = pmt.dict_add(meta, pmt.intern('user_id'),   pmt.from_long(self.user_id))
              meta = pmt.dict_add(meta, pmt.intern('frame_seq'), pmt.from_long(frame_seq))
              meta = pmt.dict_add(meta, pmt.intern('packet_id'), pmt.from_long(packet_id))
              meta = pmt.dict_add(meta, pmt.intern('degree'),    pmt.from_long(degree))
              meta = pmt.dict_add(meta, pmt.intern('this_slot'), pmt.from_long(this_slot))
              # 'packet_num' consumed by Protocol Formatter / Packet Header Generator
              meta = pmt.dict_add(meta, pmt.intern('packet_num'),pmt.from_long(frame_seq))

              pdu = pmt.cons(meta, pmt.init_u8vector(len(data), data))
              self.message_port_pub(pmt.intern('pdu_out'), pdu)

              # ── CSV log ────────────────────────────────────────────────────────
              ts = (time.strftime('%Y-%m-%d %H:%M:%S') +
                    f".{int((time.time() % 1) * 1000):03d}")
              with open(self.log_file, 'a', newline='') as f:
                  csv.writer(f).writerow([
                      packet_id, frame_seq, self.user_id, degree,
                      slot_list, this_slot, ts, f"0x{rng_seed:04X}", 'TX',
                  ])

              print(
                  f"[IRSA_TX{self.user_id}] "
                  f"Pkt={packet_id:03d}/{self.total_packets}  "
                  f"Frame={frame_seq:04d}  Slot={this_slot:03d}/{self.N_slots}  "
                  f"d={degree}  copies@{slot_list}  seed=0x{rng_seed:04X}"
              )

          # ── Frame trigger handler ──────────────────────────────────────────────

          def _on_frame_trigger(self, msg):
              """
              GNU Radio calls this in the scheduler thread when a strobe fires.
              Must return quickly — all slot transmissions are dispatched to
              threading.Timer callbacks so we don't block the scheduler.

              Decision flow
              ─────────────
              1. Warmup gate  — ignore if still in initial_delay period.
              2. Budget gate  — ignore if all total_packets already scheduled.
              3. Coin flip    — with probability (1 - tx_probability), stay silent
                                for this frame and log it as SKIP.
              4. Run IRSA     — draw degree, pick slots, schedule timers.
              5. Increment    — bump _packets_sent; if now == total_packets, fire 'done'.
              """
              if not self._ready:
                  print(f"[IRSA_TX{self.user_id}] Frame trigger ignored — still in warmup.")
                  return

              # ── Gate 1: budget exhausted ───────────────────────────────────────
              with self._lock:
                  if self._packets_sent >= self.total_packets:
                      # Already done — silently absorb any late strobe pulses
                      return
                  # Tentatively claim this frame's packet slot to avoid a race
                  # condition when timers from the previous frame are still firing.
                  # We commit unconditionally here; the coin flip below can un-claim
                  # it by decrementing if we decide to skip.
                  # Actually, we do the coin flip BEFORE claiming so the budget is
                  # only consumed on genuine transmit decisions.
                  pass  # (budget check done; proceed to coin flip)

              # ── Gate 2: random access decision ────────────────────────────────
              # Coin flip is OUTSIDE the lock — it's cheap and avoids holding the
              # lock during the print/log on a SKIP decision.
              if random.random() > self.tx_probability:
                  with self._lock:
                      self._frames_skipped += 1
                      skipped = self._frames_skipped
                      sent    = self._packets_sent
                      remaining = self.total_packets - sent

                  frame_seq = self._frame_seq
                  self._frame_seq = (self._frame_seq + 1) & 0xFFFF

                  print(
                      f"[IRSA_TX{self.user_id}] "
                      f"Frame={frame_seq:04d}  SKIP (coin)  "
                      f"remaining={remaining}/{self.total_packets}  "
                      f"total_skips={skipped}"
                  )
                  # Log the skip so we can audit TX efficiency later
                  ts = (time.strftime('%Y-%m-%d %H:%M:%S') +
                        f".{int((time.time() % 1) * 1000):03d}")
                  with open(self.log_file, 'a', newline='') as f:
                      csv.writer(f).writerow([
                          '-', frame_seq, self.user_id, '-',
                          '-', '-', ts, '-', 'SKIP',
                      ])
                  return

              # ── Claim the packet budget slot ───────────────────────────────────
              with self._lock:
                  packet_id = self._packets_sent + 1      # 1-indexed for readability
                  self._packets_sent += 1
                  is_last = (self._packets_sent >= self.total_packets)

              frame_seq = self._frame_seq
              self._frame_seq = (self._frame_seq + 1) & 0xFFFF

              # ── IRSA Algorithm ─────────────────────────────────────────────────
              # Step 1: Draw degree
              degree = self._draw_degree()

              # Step 2: Select d unique slots (1-indexed)
              chosen_slots = sorted(random.sample(range(1, self.N_slots + 1), degree))

              # Step 3: Generate shared payload ONCE — identical across all d copies
              # rng_seed    = random.randint(0, 0xFFFF)
              rng_seed    = (self.user_id * 31 + frame_seq) & 0xFFFF
              payload_len = self.packet_size - self._fixed_header_bytes
              rng         = random.Random(rng_seed)   # seeded sub-RNG for reproducibility
              random_data = [rng.randint(0, 255) for _ in range(payload_len)]

              print(
                  f"[IRSA_TX{self.user_id}] "
                  f"Pkt={packet_id:03d}/{self.total_packets}  "
                  f"Frame={frame_seq:04d}  d={degree}  slots={chosen_slots}"
                  + ("  <- LAST PACKET" if is_last else "")
              )

              # ── Step 4: Schedule one PDU per chosen slot ───────────────────────
              t_frame = time.time()   # wall-clock anchor for this frame

              with self._lock:
                  # Clean up completed timers from previous frames
                  self._timers = [t for t in self._timers if t.is_alive()]

                  for slot in chosen_slots:
                      delay = (slot - 1) * self.slot_duration

                      t = threading.Timer(
                          interval = delay,
                          function = self._emit_slot,
                          args     = (packet_id, frame_seq, degree, slot,
                                      chosen_slots, rng_seed, random_data),
                      )
                      t.daemon = True
                      t.start()
                      self._timers.append(t)

              # ── Step 5: Fire 'done' when budget is exhausted ───────────────────
              if is_last:
                  # Delay the 'done' signal until after the last slot timer has had
                  # time to fire, so downstream blocks aren't torn down prematurely.
                  last_slot_delay = (max(chosen_slots) - 1) * self.slot_duration + 0.5
                  done_timer = threading.Timer(
                      interval = last_slot_delay,
                      function = self._signal_done,
                  )
                  done_timer.daemon = True
                  done_timer.start()

          # ── Lifecycle helpers ──────────────────────────────────────────────────

          def _signal_done(self):
              """
              Fires once, after the last slot timer has had time to emit.
              Publishes a PMT symbol on the 'done' port so the flowgraph can
              self-terminate (e.g. connect to a Message Debug or a custom stopper).
              """
              msg = pmt.cons(
                  pmt.intern('done'),
                  pmt.from_long(self.user_id),
              )
              self.message_port_pub(pmt.intern('done'), msg)
              print(
                  f"[IRSA_TX{self.user_id}] DONE — "
                  f"all {self.total_packets} packets scheduled, "
                  f"frames_skipped={self._frames_skipped}"
              )

          def stop(self):
              """Cancel all pending slot timers on flowgraph stop."""
              with self._lock:
                  for t in self._timers:
                      t.cancel()
                  self._timers.clear()
              print(
                  f"[IRSA_TX{self.user_id}] Stopped. "
                  f"packets_sent={self._packets_sent}/{self.total_packets}  "
                  f"frames_processed={self._frame_seq}  "
                  f"frames_skipped={self._frames_skipped}"
              )
              return True
    initial_delay: initial_delay
    lambda_dist: dist
    packet_size: packet_size
    slot_duration: T_slot
    total_packets: '1'
    tx_probability: '1'
    user_id: user_id1
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import collections

      class PDU_to_Timed_Byte_Stream(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='PDU to Timed Byte Stream',
                  in_sig=None,
                  out_sig=[np.uint8, np.uint8] # Port 0: Data, Port 1: Gate
              )
              self.message_port_register_in(pmt.intern("pdus"))
              self.set_msg_handler(pmt.intern("pdus"), self.handle_msg)
              
              self.byte_buffer = collections.deque()
              # Track the start of new packets for tagging
              self.packet_lengths = collections.deque() 
              self.bytes_left_in_packet = 0

          def handle_msg(self, msg):
              data = pmt.u8vector_elements(pmt.cdr(msg))
              p_len = len(data)
              # Store the data and the length of this specific packet
              for b in data:
                  self.byte_buffer.append(b)
              self.packet_lengths.append(p_len)

          def work(self, input_items, output_items):
              out_data = output_items[0]
              out_gate = output_items[1]
              n = len(out_data)

              for i in range(n):
                  if self.byte_buffer:
                      # Logic to detect the exact start of a burst
                      if self.bytes_left_in_packet == 0 and self.packet_lengths:
                          self.bytes_left_in_packet = self.packet_lengths.popleft()
                          
                          # Add the Stream Tag
                          key = pmt.intern("burst_start")
                          value = pmt.from_long(1)
                          # self.add_item_tag(0, self.nitems_written(0) + i, key, value)
                          self.add_item_tag(1, self.nitems_written(1) + i, key, value)
                      
                      out_data[i] = self.byte_buffer.popleft()
                      out_gate[i] = 1
                      # if i==0 or i==n-1:
                      #     print("gate activated at index", i)
                      #     print(n, self.bytes_left_in_packet)
                      
                      if self.bytes_left_in_packet > 0:
                          self.bytes_left_in_packet -= 1
                  else:
                      out_data[i] = 0
                      out_gate[i] = 0
                      self.bytes_left_in_packet = 0 # Reset just in case

              return n
  states: {}
- name: epy_block_0_1_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import collections

      class PDU_to_Timed_Byte_Stream(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='PDU to Timed Byte Stream',
                  in_sig=None,
                  out_sig=[np.uint8, np.uint8] # Port 0: Data, Port 1: Gate
              )
              self.message_port_register_in(pmt.intern("pdus"))
              self.set_msg_handler(pmt.intern("pdus"), self.handle_msg)
              
              self.byte_buffer = collections.deque()
              # Track the start of new packets for tagging
              self.packet_lengths = collections.deque() 
              self.bytes_left_in_packet = 0

          def handle_msg(self, msg):
              data = pmt.u8vector_elements(pmt.cdr(msg))
              p_len = len(data)
              # Store the data and the length of this specific packet
              for b in data:
                  self.byte_buffer.append(b)
              self.packet_lengths.append(p_len)

          def work(self, input_items, output_items):
              out_data = output_items[0]
              out_gate = output_items[1]
              n = len(out_data)

              for i in range(n):
                  if self.byte_buffer:
                      # Logic to detect the exact start of a burst
                      if self.bytes_left_in_packet == 0 and self.packet_lengths:
                          self.bytes_left_in_packet = self.packet_lengths.popleft()
                          
                          # Add the Stream Tag
                          key = pmt.intern("burst_start")
                          value = pmt.from_long(1)
                          # self.add_item_tag(0, self.nitems_written(0) + i, key, value)
                          self.add_item_tag(1, self.nitems_written(1) + i, key, value)
                      
                      out_data[i] = self.byte_buffer.popleft()
                      out_gate[i] = 1
                      # if i==0 or i==n-1:
                      #     print("gate activated at index", i)
                      #     print(n, self.bytes_left_in_packet)
                      
                      if self.bytes_left_in_packet > 0:
                          self.bytes_left_in_packet -= 1
                  else:
                      out_data[i] = 0
                      out_gate[i] = 0
                      self.bytes_left_in_packet = 0 # Reset just in case

              return n
  states: {}
- name: fft_filter_xxx_0_0_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0_0_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: TX1_c
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: TX1_F
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: TX1_T
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    tr_tag: '''burst_start'''
    type: complex
  states: {}
- name: rx_log
  id: parameter
  parameters:
    label: file
    type: str
    value: rx_log.csv
  states: {}
- name: virtual_sink_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: ch_out
  states: {}
- name: virtual_sink_0_1_0_1_0
  id: virtual_sink
  parameters:
    stream_id: sig1
  states: {}
- name: virtual_sink_0_1_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: sig12
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: ch_out
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: sig1
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_const_source_x_0_0_0, '0', blocks_float_to_complex_0_0_0, '1']
- [analog_const_source_x_0_0_0_0, '0', blocks_float_to_complex_0_0_0_0, '1']
- [blocks_add_xx_0, '0', channels_channel_model_0, '0']
- [blocks_float_to_complex_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_float_to_complex_0_0_0_0, '0', blocks_multiply_xx_0_0_0_0, '0']
- [blocks_message_strobe_0, strobe, epy_block_0, frame_trigger]
- [blocks_message_strobe_0_0, strobe, epy_block_0_0, frame_trigger]
- [blocks_multiply_xx_0_0_0, '0', fft_filter_xxx_0_0_0_0_0, '0']
- [blocks_multiply_xx_0_0_0_0, '0', fft_filter_xxx_0_0_0_0_0_0, '0']
- [blocks_repeat_0_0_0, '0', blocks_float_to_complex_0_0_0, '0']
- [blocks_repeat_0_0_0_0, '0', blocks_float_to_complex_0_0_0_0, '0']
- [blocks_throttle2_0_0, '0', virtual_sink_0_1_0_0, '0']
- [blocks_uchar_to_float_0_1, '0', blocks_repeat_0_0_0, '0']
- [blocks_uchar_to_float_0_1_0, '0', blocks_repeat_0_0_0_0, '0']
- [channels_channel_model_0, '0', blocks_throttle2_0_0, '0']
- [digital_constellation_modulator_0_0_0_0, '0', blocks_multiply_xx_0_0_0, '0']
- [digital_constellation_modulator_0_0_0_0_0, '0', blocks_multiply_xx_0_0_0_0, '1']
- [epy_block_0, pdu_out, blocks_message_debug_0, print]
- [epy_block_0, pdu_out, epy_block_0_1, pdus]
- [epy_block_0_0, pdu_out, epy_block_0_1_0, pdus]
- [epy_block_0_1, '0', digital_constellation_modulator_0_0_0_0, '0']
- [epy_block_0_1, '1', blocks_uchar_to_float_0_1, '0']
- [epy_block_0_1_0, '0', digital_constellation_modulator_0_0_0_0_0, '0']
- [epy_block_0_1_0, '1', blocks_uchar_to_float_0_1_0, '0']
- [fft_filter_xxx_0_0_0_0_0, '0', virtual_sink_0_1_0_1_0, '0']
- [fft_filter_xxx_0_0_0_0_0_0, '0', virtual_sink_0_1_0_1_0_0, '0']
- [virtual_source_1_0, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_1_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_1_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_1_0_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
