options:
  parameters:
    author: Barry Duggan
    description: packet transmit
    generate_options: qt_gui
    id: pkt_xmt
    output_language: python
    title: pkt_xmt
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''1010101010101010101010101010101011100001010110101110100010010011'''
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: bw
  id: variable
  parameters:
    value: (1+excess_bw)*(samp_rate//sps)
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: (bw//2)+5e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: user_id1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: user_id2
  id: variable
  parameters:
    value: '2'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: InFile
  id: parameter
  parameters:
    label: File Name
    type: str
    value: file.txt
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: iq_samples.dat
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_meta_sink_0_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: iq_samples.dat
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: tx1
    type: complex
  states: {}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    name: tx2
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: sps*8
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_1
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: sps*8
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: usrp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: usrp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: usrp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_protocol_formatter_bb_0_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    FileName: InFile
    Pkt_len: '52'
    _source_code: "\"\"\"\nEmbedded Python Block: File Source to Tagged Stream\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport pmt\nimport os.path\nimport sys\nimport base64\n\n\"\"\"\nState definitions\n    0   idle\n    1   send preamble\n    2   send file data\n    3   send file name\n    4   send post filler\n\"\"\"\n\nclass blk(gr.sync_block):\n    def __init__(self, FileName='None', Pkt_len=52, mean_interval=0.1):\n        gr.sync_block.__init__(\n            self,\n            name='EPB: File Source with Random Packet Generator', # to Tagged Stream \n            in_sig=None,\n            out_sig=[np.uint8]\n        )\n\n        self.FileName = FileName\n        self.Pkt_len = Pkt_len # in Bytes\n        self.state = 0      # idle state\n        self.pre_count = 0\n        self.indx = 0\n        self._debug = 0     # debug\n        self.data = \"\"\n        self.nitems_written = 0\n\n        # adding to the existing code to have random packet generator with mean interval between packets\n        self.mean_interval = mean_interval # mean interval between packets in seconds\n\n        if os.path.exists(self.FileName):\n            self.f_in = open(self.FileName, 'rb')\n            self._eof = False\n            if self._debug:\n                print(\"File name:\", self.FileName)\n            self.state = 1\n        else:\n            print(self.FileName, 'does not exist')\n            self._eof = True\n            self.state = 0\n\n        self.char_list = [\n            37,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,\n            85,85,85,93\n        ]\n        self.c_len = len(self.char_list)\n\n        self.filler = [\n            37,85,85,85,35,69,79,70,\n            85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,\n            85,85,85,93\n        ]\n        self.f_len = len(self.filler)\n\n    def work(self, input_items, output_items):\n\n        while True:\n            if self.state == 0:\n                return 0\n            else:\n                wait_time = np.random.exponential(self.mean_interval)\n                time.sleep(wait_time)\n                \n                # if self.state == 0:\n                #     return 0\n\n                if self.state == 1:\n\n                    buff = self.f_in.read(self.Pkt_len)\n                    b_len = len(buff)\n\n                    if b_len == 0:\n                        print('File is empty')\n                        self._eof = False\n                        self.f_in.close()\n                        self.state = 0\n                        self.pre_count = 0\n                        return 0\n\n                    if self._debug:\n                        print(\"state = 1\", self.pre_count)\n\n                    key1 = pmt.intern(\"packet_len\")\n                    val1 = pmt.from_long(self.c_len)\n\n                    if len(output_items[0]) < self.c_len:\n                        return 0\n\n                    self.add_item_tag(\n                        0,\n                        self.nitems_written,\n                        key1,\n                        val1\n                    )\n\n                    self.indx += self.c_len\n                    self.nitems_written += self.c_len\n\n                    i = 0\n                    while i < self.c_len:\n                        output_items[0][i] = self.char_list[i]\n                        i += 1\n\n                    self.pre_count += 1\n                    if self.pre_count > 64:\n                        self.pre_count = 0\n                        self.state = 2\n\n                    return self.c_len\n\n                elif self.state == 2:\n                    buff = self.f_in.read(self.Pkt_len)\n                    b_len = len(buff)\n\n                    if b_len == 0:\n                        print('End of file')\n                        self._eof = True\n                        self.f_in.close()\n                        self.state = 3\n                        self.pre_count = 0\n                        return 0\n\n                    encoded = base64.b64encode(buff)\n                    e_len = len(encoded)\n\n                    if self._debug:\n                        print('b64 length =', e_len)\n\n                    key0 = pmt.intern(\"packet_len\")\n                    val0 = pmt.from_long(e_len)\n\n                    if len(output_items[0]) < e_len:\n                        return 0\n\n                    self.add_item_tag(\n                        0,\n                        self.nitems_written,\n                        key0,\n                        val0\n                    )\n\n                    self.indx += e_len\n                    self.nitems_written += e_len\n\n                    i = 0\n                    while i < e_len:\n                        output_items[0][i] = encoded[i]\n                        i += 1\n\n                    return e_len\n\n                elif self.state == 3:\n                    fn_len = len(self.FileName)\n\n                    key1 = pmt.intern(\"packet_len\")\n                    val1 = pmt.from_long(fn_len + 8)\n\n                    if len(output_items[0]) < fn_len + 8:\n                        return 0\n\n                    self.add_item_tag(\n                        0,\n                        self.nitems_written,\n                        key1,\n                        val1\n                    )\n\n                    self.indx += fn_len + 8\n                    self.nitems_written += fn_len + 8\n\n                    i = 0\n                    while i < 8:\n                        output_items[0][i] = self.filler[i]\n                        i += 1\n\n                    j = 0\n                    while i < (fn_len + 8):\n                        output_items[0][i] = ord(self.FileName[j])\n                        i += 1\n                        j += 1\n\n                    self.state = 4\n                    return fn_len + 8\n\n                elif self.state == 4:\n                    if self._debug:\n                        print(\"state = 4\", self.pre_count)\n\n                    key1 = pmt.intern(\"packet_len\")\n                    val1 = pmt.from_long(self.f_len)\n\n                    if len(output_items[0]) < self.f_len:\n                        return 0\n\n                    self.add_item_tag(\n                        0,\n                        self.nitems_written,\n                        key1,\n                        val1\n                    )\n\n                    self.indx += self.f_len\n                    self.nitems_written += self.f_len\n\n                    i = 0\n                    while i < self.f_len:\n                        output_items[0][i] = self.filler[i]\n                        i += 1\n\n                    self.pre_count += 1\n                    if self.pre_count > 16:\n                        self.pre_count = 0\n                        self.state = 0\n\n                    return self.f_len\n\n                return 0\n        \n"
    comment: |-
      Filename is specified on the command line, e.g.:
      python3 pkt_xmt.py --InFile="../gr-logo.png"
    mean_interval: '0.1'
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    FileName: InFile
    Pkt_len: '52'
    _source_code: "\"\"\"\nEmbedded Python Block: File Source to Tagged Stream\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport pmt\nimport os.path\nimport sys\nimport base64\n\n\"\"\"\nState definitions\n    0   idle\n    1   send preamble\n    2   send file data\n    3   send file name\n    4   send post filler\n\"\"\"\n\nclass blk(gr.sync_block):\n    def __init__(self, FileName='None', Pkt_len=52, mean_interval=0.1):\n        gr.sync_block.__init__(\n            self,\n            name='EPB: File Source with Random Packet Generator', # to Tagged Stream \n            in_sig=None,\n            out_sig=[np.uint8]\n        )\n\n        self.FileName = FileName\n        self.Pkt_len = Pkt_len # in Bytes\n        self.state = 0      # idle state\n        self.pre_count = 0\n        self.indx = 0\n        self._debug = 0     # debug\n        self.data = \"\"\n        self.nitems_written = 0\n\n        # adding to the existing code to have random packet generator with mean interval between packets\n        self.mean_interval = mean_interval # mean interval between packets in seconds\n\n        if os.path.exists(self.FileName):\n            self.f_in = open(self.FileName, 'rb')\n            self._eof = False\n            if self._debug:\n                print(\"File name:\", self.FileName)\n            self.state = 1\n        else:\n            print(self.FileName, 'does not exist')\n            self._eof = True\n            self.state = 0\n\n        self.char_list = [\n            37,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,\n            85,85,85,93\n        ]\n        self.c_len = len(self.char_list)\n\n        self.filler = [\n            37,85,85,85,35,69,79,70,\n            85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,\n            85,85,85,85,85,85,85,85,\n            85,85,85,93\n        ]\n        self.f_len = len(self.filler)\n\n    def work(self, input_items, output_items):\n\n        while True:\n            if self.state == 0:\n                return 0\n            else:\n                wait_time = np.random.exponential(self.mean_interval)\n                time.sleep(wait_time)\n                \n                # if self.state == 0:\n                #     return 0\n\n                if self.state == 1:\n\n                    buff = self.f_in.read(self.Pkt_len)\n                    b_len = len(buff)\n\n                    if b_len == 0:\n                        print('File is empty')\n                        self._eof = False\n                        self.f_in.close()\n                        self.state = 0\n                        self.pre_count = 0\n                        return 0\n\n                    if self._debug:\n                        print(\"state = 1\", self.pre_count)\n\n                    key1 = pmt.intern(\"packet_len\")\n                    val1 = pmt.from_long(self.c_len)\n\n                    if len(output_items[0]) < self.c_len:\n                        return 0\n\n                    self.add_item_tag(\n                        0,\n                        self.nitems_written,\n                        key1,\n                        val1\n                    )\n\n                    self.indx += self.c_len\n                    self.nitems_written += self.c_len\n\n                    i = 0\n                    while i < self.c_len:\n                        output_items[0][i] = self.char_list[i]\n                        i += 1\n\n                    self.pre_count += 1\n                    if self.pre_count > 64:\n                        self.pre_count = 0\n                        self.state = 2\n\n                    return self.c_len\n\n                elif self.state == 2:\n                    buff = self.f_in.read(self.Pkt_len)\n                    b_len = len(buff)\n\n                    if b_len == 0:\n                        print('End of file')\n                        self._eof = True\n                        self.f_in.close()\n                        self.state = 3\n                        self.pre_count = 0\n                        return 0\n\n                    encoded = base64.b64encode(buff)\n                    e_len = len(encoded)\n\n                    if self._debug:\n                        print('b64 length =', e_len)\n\n                    key0 = pmt.intern(\"packet_len\")\n                    val0 = pmt.from_long(e_len)\n\n                    if len(output_items[0]) < e_len:\n                        return 0\n\n                    self.add_item_tag(\n                        0,\n                        self.nitems_written,\n                        key0,\n                        val0\n                    )\n\n                    self.indx += e_len\n                    self.nitems_written += e_len\n\n                    i = 0\n                    while i < e_len:\n                        output_items[0][i] = encoded[i]\n                        i += 1\n\n                    return e_len\n\n                elif self.state == 3:\n                    fn_len = len(self.FileName)\n\n                    key1 = pmt.intern(\"packet_len\")\n                    val1 = pmt.from_long(fn_len + 8)\n\n                    if len(output_items[0]) < fn_len + 8:\n                        return 0\n\n                    self.add_item_tag(\n                        0,\n                        self.nitems_written,\n                        key1,\n                        val1\n                    )\n\n                    self.indx += fn_len + 8\n                    self.nitems_written += fn_len + 8\n\n                    i = 0\n                    while i < 8:\n                        output_items[0][i] = self.filler[i]\n                        i += 1\n\n                    j = 0\n                    while i < (fn_len + 8):\n                        output_items[0][i] = ord(self.FileName[j])\n                        i += 1\n                        j += 1\n\n                    self.state = 4\n                    return fn_len + 8\n\n                elif self.state == 4:\n                    if self._debug:\n                        print(\"state = 4\", self.pre_count)\n\n                    key1 = pmt.intern(\"packet_len\")\n                    val1 = pmt.from_long(self.f_len)\n\n                    if len(output_items[0]) < self.f_len:\n                        return 0\n\n                    self.add_item_tag(\n                        0,\n                        self.nitems_written,\n                        key1,\n                        val1\n                    )\n\n                    self.indx += self.f_len\n                    self.nitems_written += self.f_len\n\n                    i = 0\n                    while i < self.f_len:\n                        output_items[0][i] = self.filler[i]\n                        i += 1\n\n                    self.pre_count += 1\n                    if self.pre_count > 16:\n                        self.pre_count = 0\n                        self.state = 0\n\n                    return self.f_len\n\n                return 0\n        \n"
    comment: |-
      Filename is specified on the command line, e.g.:
      python3 pkt_xmt.py --InFile="../gr-logo.png"
    mean_interval: '0.1'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      #!/usr/bin/env python
      from gnuradio import gr
      import numpy as np
      import time
      import csv

      class iq_logger_with_timestamp(gr.sync_block):
          def __init__(self, iq_csv_filename="iq_samples.csv"):
              gr.sync_block.__init__(
                  self,
                  name="iq_logger_with_timestamp",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.iq_csv_filename = iq_csv_filename
              self.sample_count = 0

              # Initialize CSV with header (same pattern as Random_Packet_Generator)
              with open(self.iq_csv_filename, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'sample_index',
                      'timestamp',
                      'num_samples',
                      'i_values',
                      'q_values'
                  ])

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              # Timestamp with millisecond precision (matches Random_Packet_Generator style)
              timestamp = time.strftime('%Y-%m-%d %H:%M:%S') + \
                          f".{int((time.time() % 1) * 1000):03d}"

              num_samples = len(in0)

              # Split complex64 into separate I and Q lists
              i_values = in0.real.tolist()
              q_values = in0.imag.tolist()

              # Append row to CSV
              with open(self.iq_csv_filename, 'a', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      self.sample_count,
                      timestamp,
                      num_samples,
                      i_values,
                      q_values
                  ])

              self.sample_count += num_samples

              # Pass samples through unchanged
              out0[:] = in0
              return len(out0)

          def stop(self):
              print(f"[IQ Logger] Finished. Total samples logged: {self.sample_count}")
              return True
    iq_csv_filename: iq1_1
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |-
      #!/usr/bin/env python
      from gnuradio import gr
      import numpy as np
      import time
      import csv

      class iq_logger_with_timestamp(gr.sync_block):
          def __init__(self, iq_csv_filename="iq_samples.csv"):
              gr.sync_block.__init__(
                  self,
                  name="iq_logger_with_timestamp",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.iq_csv_filename = iq_csv_filename
              self.sample_count = 0

              # Initialize CSV with header (same pattern as Random_Packet_Generator)
              with open(self.iq_csv_filename, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'sample_index',
                      'timestamp',
                      'num_samples',
                      'i_values',
                      'q_values'
                  ])

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              # Timestamp with millisecond precision (matches Random_Packet_Generator style)
              timestamp = time.strftime('%Y-%m-%d %H:%M:%S') + \
                          f".{int((time.time() % 1) * 1000):03d}"

              num_samples = len(in0)

              # Split complex64 into separate I and Q lists
              i_values = in0.real.tolist()
              q_values = in0.imag.tolist()

              # Append row to CSV
              with open(self.iq_csv_filename, 'a', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      self.sample_count,
                      timestamp,
                      num_samples,
                      i_values,
                      q_values
                  ])

              self.sample_count += num_samples

              # Pass samples through unchanged
              out0[:] = in0
              return len(out0)

          def stop(self):
              print(f"[IQ Logger] Finished. Total samples logged: {self.sample_count}")
              return True
    iq_csv_filename: iq1_2
  states: {state: disabled}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: |-
      #!/usr/bin/env python
      from gnuradio import gr
      import numpy as np
      import time
      import csv

      class iq_logger_with_timestamp(gr.sync_block):
          def __init__(self, iq_csv_filename="iq_samples.csv"):
              gr.sync_block.__init__(
                  self,
                  name="iq_logger_with_timestamp",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.iq_csv_filename = iq_csv_filename
              self.sample_count = 0

              # Initialize CSV with header (same pattern as Random_Packet_Generator)
              with open(self.iq_csv_filename, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'sample_index',
                      'timestamp',
                      'num_samples',
                      'i_values',
                      'q_values'
                  ])

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              # Timestamp with millisecond precision (matches Random_Packet_Generator style)
              timestamp = time.strftime('%Y-%m-%d %H:%M:%S') + \
                          f".{int((time.time() % 1) * 1000):03d}"

              num_samples = len(in0)

              # Split complex64 into separate I and Q lists
              i_values = in0.real.tolist()
              q_values = in0.imag.tolist()

              # Append row to CSV
              with open(self.iq_csv_filename, 'a', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      self.sample_count,
                      timestamp,
                      num_samples,
                      i_values,
                      q_values
                  ])

              self.sample_count += num_samples

              # Pass samples through unchanged
              out0[:] = in0
              return len(out0)

          def stop(self):
              print(f"[IQ Logger] Finished. Total samples logged: {self.sample_count}")
              return True
    iq_csv_filename: iq1_2
  states: {}
- name: epy_block_1_0_0_0
  id: epy_block
  parameters:
    _source_code: |-
      #!/usr/bin/env python
      from gnuradio import gr
      import numpy as np
      import time
      import csv

      class iq_logger_with_timestamp(gr.sync_block):
          def __init__(self, iq_csv_filename="iq_samples.csv"):
              gr.sync_block.__init__(
                  self,
                  name="iq_logger_with_timestamp",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.iq_csv_filename = iq_csv_filename
              self.sample_count = 0

              # Initialize CSV with header (same pattern as Random_Packet_Generator)
              with open(self.iq_csv_filename, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'sample_index',
                      'timestamp',
                      'num_samples',
                      'i_values',
                      'q_values'
                  ])

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              # Timestamp with millisecond precision (matches Random_Packet_Generator style)
              timestamp = time.strftime('%Y-%m-%d %H:%M:%S') + \
                          f".{int((time.time() % 1) * 1000):03d}"

              num_samples = len(in0)

              # Split complex64 into separate I and Q lists
              i_values = in0.real.tolist()
              q_values = in0.imag.tolist()

              # Append row to CSV
              with open(self.iq_csv_filename, 'a', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      self.sample_count,
                      timestamp,
                      num_samples,
                      i_values,
                      q_values
                  ])

              self.sample_count += num_samples

              # Pass samples through unchanged
              out0[:] = in0
              return len(out0)

          def stop(self):
              print(f"[IQ Logger] Finished. Total samples logged: {self.sample_count}")
              return True
    iq_csv_filename: iq2_2
  states: {}
- name: epy_block_1_0_0_1
  id: epy_block
  parameters:
    _source_code: |-
      #!/usr/bin/env python
      from gnuradio import gr
      import numpy as np
      import time
      import csv

      class iq_logger_with_timestamp(gr.sync_block):
          def __init__(self, iq_csv_filename="iq_samples.csv"):
              gr.sync_block.__init__(
                  self,
                  name="iq_logger_with_timestamp",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.iq_csv_filename = iq_csv_filename
              self.sample_count = 0

              # Initialize CSV with header (same pattern as Random_Packet_Generator)
              with open(self.iq_csv_filename, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'sample_index',
                      'timestamp',
                      'num_samples',
                      'i_values',
                      'q_values'
                  ])

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              # Timestamp with millisecond precision (matches Random_Packet_Generator style)
              timestamp = time.strftime('%Y-%m-%d %H:%M:%S') + \
                          f".{int((time.time() % 1) * 1000):03d}"

              num_samples = len(in0)

              # Split complex64 into separate I and Q lists
              i_values = in0.real.tolist()
              q_values = in0.imag.tolist()

              # Append row to CSV
              with open(self.iq_csv_filename, 'a', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      self.sample_count,
                      timestamp,
                      num_samples,
                      i_values,
                      q_values
                  ])

              self.sample_count += num_samples

              # Pass samples through unchanged
              out0[:] = in0
              return len(out0)

          def stop(self):
              print(f"[IQ Logger] Finished. Total samples logged: {self.sample_count}")
              return True
    iq_csv_filename: iq_add
  states: {}
- name: epy_block_1_0_0_2
  id: epy_block
  parameters:
    _source_code: |-
      #!/usr/bin/env python
      from gnuradio import gr
      import numpy as np
      import time
      import csv

      class iq_logger_with_timestamp(gr.sync_block):
          def __init__(self, iq_csv_filename="iq_samples.csv"):
              gr.sync_block.__init__(
                  self,
                  name="iq_logger_with_timestamp",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.iq_csv_filename = iq_csv_filename
              self.sample_count = 0

              # Initialize CSV with header (same pattern as Random_Packet_Generator)
              with open(self.iq_csv_filename, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'sample_index',
                      'timestamp',
                      'num_samples',
                      'i_values',
                      'q_values'
                  ])

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              # Timestamp with millisecond precision (matches Random_Packet_Generator style)
              timestamp = time.strftime('%Y-%m-%d %H:%M:%S') + \
                          f".{int((time.time() % 1) * 1000):03d}"

              num_samples = len(in0)

              # Split complex64 into separate I and Q lists
              i_values = in0.real.tolist()
              q_values = in0.imag.tolist()

              # Append row to CSV
              with open(self.iq_csv_filename, 'a', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      self.sample_count,
                      timestamp,
                      num_samples,
                      i_values,
                      q_values
                  ])

              self.sample_count += num_samples

              # Pass samples through unchanged
              out0[:] = in0
              return len(out0)

          def stop(self):
              print(f"[IQ Logger] Finished. Total samples logged: {self.sample_count}")
              return True
    iq_csv_filename: iq1_2
  states: {}
- name: epy_block_1_1
  id: epy_block
  parameters:
    _source_code: |-
      #!/usr/bin/env python
      from gnuradio import gr
      import numpy as np
      import time
      import csv

      class iq_logger_with_timestamp(gr.sync_block):
          def __init__(self, iq_csv_filename="iq_samples.csv"):
              gr.sync_block.__init__(
                  self,
                  name="iq_logger_with_timestamp",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.iq_csv_filename = iq_csv_filename
              self.sample_count = 0

              # Initialize CSV with header (same pattern as Random_Packet_Generator)
              with open(self.iq_csv_filename, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'sample_index',
                      'timestamp',
                      'num_samples',
                      'i_values',
                      'q_values'
                  ])

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              # Timestamp with millisecond precision (matches Random_Packet_Generator style)
              timestamp = time.strftime('%Y-%m-%d %H:%M:%S') + \
                          f".{int((time.time() % 1) * 1000):03d}"

              num_samples = len(in0)

              # Split complex64 into separate I and Q lists
              i_values = in0.real.tolist()
              q_values = in0.imag.tolist()

              # Append row to CSV
              with open(self.iq_csv_filename, 'a', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      self.sample_count,
                      timestamp,
                      num_samples,
                      i_values,
                      q_values
                  ])

              self.sample_count += num_samples

              # Pass samples through unchanged
              out0[:] = in0
              return len(out0)

          def stop(self):
              print(f"[IQ Logger] Finished. Total samples logged: {self.sample_count}")
              return True
    iq_csv_filename: iq2_1
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt
      import random
      import time
      import threading
      import csv

      class Random_Packet_Generator(gr.basic_block):
          """
          Random Packet Generator with embedded userid and sequence number.

          Packet payload layout:
              [0:2]  – seq_num  : 2 bytes, big-endian uint16
              [2:4]  – user_id  : 2 bytes, big-endian uint16  (0–65535)
              [4:]   – random data : fills the rest up to packet_size bytes

          The PMT metadata dict carries:
              'packet_num' → seq_num  (used by Packet Header Generator block)
              'user_id'    → user_id  (informational)
          """

          def __init__(self,
                       mean_interval=0.1,
                       packet_size=100,
                       user_id=1,
                       log_file="transmitted_packets.csv", total_packets=10):

              gr.basic_block.__init__(self,
                  name="random_packet_generator",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_out(pmt.intern('pdu_out'))

              # ── Parameters ────────────────────────────────────────────────
              self.mean_interval = mean_interval
              self.packet_size   = packet_size
              self.user_id       = int(user_id) & 0xFFFF   # clamp to uint16
              self.log_file      = log_file
              self.total_packets = total_packets

              self.packet_count  = 0

              # Header overhead: seq(2) + user_id(2) = 4 bytes
              if packet_size <= 4:
                  raise ValueError(
                      f"packet_size ({packet_size}) must be > 4 to fit the header"
                  )

              # ── Init CSV log ──────────────────────────────────────────────
              with open(self.log_file, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'packet_id', 'timestamp', 'user_id',
                      'wait_time_s', 'data_hex', 'data_bytes'
                  ])

              # ── Start generator thread ────────────────────────────────────
              self.thread = threading.Thread(target=self._generate_packets, daemon=True)
              self.thread.start()

          # ─────────────────────────────────────────────────────────────────
          def _build_payload(self, seq: int) -> list:
              """
              Assemble the byte payload:
                  [seq_hi, seq_lo, uid_hi, uid_lo, *random_bytes]
              """
              header = [
                  (seq          >> 8) & 0xFF,   # seq high byte
                   seq                & 0xFF,   # seq low byte
                  (self.user_id >> 8) & 0xFF,   # user_id high byte
                   self.user_id       & 0xFF,   # user_id low byte
              ]
              random_bytes = [random.randint(0, 255)
                              for _ in range(self.packet_size - len(header))]
              return header + random_bytes

          # ─────────────────────────────────────────────────────────────────
          def _generate_packets(self):
              seq = 0
              time.sleep(random.uniform(0, self.mean_interval))
              while self.packet_count < self.total_packets:
                  wait_time = random.expovariate(1.0 / self.mean_interval)
                  time.sleep(wait_time)

                  data = self._build_payload(seq)

                  # ── Build PMT metadata dict ───────────────────────────────
                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta,
                                      pmt.intern('packet_num'),
                                      pmt.from_long(seq))             # Packet Header Generator
                  meta = pmt.dict_add(meta,
                                      pmt.intern('user_id'),
                                      pmt.from_long(self.user_id))    # informational

                  # ── Publish PDU ───────────────────────────────────────────
                  pdu = pmt.cons(meta, pmt.init_u8vector(len(data), data))
                  self.message_port_pub(pmt.intern('pdu_out'), pdu)

                  self.packet_count += 1
                  seq = (seq + 1) & 0xFFFF    # 16-bit rollover

                  # ── CSV logging ───────────────────────────────────────────
                  timestamp = (time.strftime('%Y-%m-%d %H:%M:%S') +
                               f".{int((time.time() % 1) * 1000):03d}")
                  data_hex  = ' '.join(f'{b:02X}' for b in data)

                  with open(self.log_file, 'a', newline='') as f:
                      writer = csv.writer(f)
                      writer.writerow([
                          self.packet_count,
                          timestamp,
                          self.user_id,
                          f"{wait_time:.4f}",
                          data_hex,
                          list(data)
                      ])

                  print(f"[PKT {self.packet_count:03d}] user_id={self.user_id} "
                        f"seq={seq - 1 & 0xFFFF:#06x} "
                        f"after {wait_time:.3f}s | "
                        f"first 4B: {data_hex.split()[:4]}")
    log_file: log_file1
    mean_interval: '1.6'
    packet_size: '20'
    total_packets: '3'
    user_id: '1'
  states: {}
- name: epy_block_2_1
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt
      import random
      import time
      import threading
      import csv

      class Random_Packet_Generator(gr.basic_block):
          """
          Random Packet Generator with embedded userid and sequence number.

          Packet payload layout:
              [0:2]  – seq_num  : 2 bytes, big-endian uint16
              [2:4]  – user_id  : 2 bytes, big-endian uint16  (0–65535)
              [4:]   – random data : fills the rest up to packet_size bytes

          The PMT metadata dict carries:
              'packet_num' → seq_num  (used by Packet Header Generator block)
              'user_id'    → user_id  (informational)
          """

          def __init__(self,
                       mean_interval=0.1,
                       packet_size=100,
                       user_id=1,
                       log_file="transmitted_packets.csv", total_packets=10):

              gr.basic_block.__init__(self,
                  name="random_packet_generator",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_out(pmt.intern('pdu_out'))

              # ── Parameters ────────────────────────────────────────────────
              self.mean_interval = mean_interval
              self.packet_size   = packet_size
              self.user_id       = int(user_id) & 0xFFFF   # clamp to uint16
              self.log_file      = log_file
              self.total_packets = total_packets

              self.packet_count  = 0

              # Header overhead: seq(2) + user_id(2) = 4 bytes
              if packet_size <= 4:
                  raise ValueError(
                      f"packet_size ({packet_size}) must be > 4 to fit the header"
                  )

              # ── Init CSV log ──────────────────────────────────────────────
              with open(self.log_file, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'packet_id', 'timestamp', 'user_id',
                      'wait_time_s', 'data_hex', 'data_bytes'
                  ])

              # ── Start generator thread ────────────────────────────────────
              self.thread = threading.Thread(target=self._generate_packets, daemon=True)
              self.thread.start()

          # ─────────────────────────────────────────────────────────────────
          def _build_payload(self, seq: int) -> list:
              """
              Assemble the byte payload:
                  [seq_hi, seq_lo, uid_hi, uid_lo, *random_bytes]
              """
              header = [
                  (seq          >> 8) & 0xFF,   # seq high byte
                   seq                & 0xFF,   # seq low byte
                  (self.user_id >> 8) & 0xFF,   # user_id high byte
                   self.user_id       & 0xFF,   # user_id low byte
              ]
              random_bytes = [random.randint(0, 255)
                              for _ in range(self.packet_size - len(header))]
              return header + random_bytes

          # ─────────────────────────────────────────────────────────────────
          def _generate_packets(self):
              seq = 0
              time.sleep(random.uniform(0, self.mean_interval))
              while self.packet_count < self.total_packets:
                  wait_time = random.expovariate(1.0 / self.mean_interval)
                  time.sleep(wait_time)

                  data = self._build_payload(seq)

                  # ── Build PMT metadata dict ───────────────────────────────
                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta,
                                      pmt.intern('packet_num'),
                                      pmt.from_long(seq))             # Packet Header Generator
                  meta = pmt.dict_add(meta,
                                      pmt.intern('user_id'),
                                      pmt.from_long(self.user_id))    # informational

                  # ── Publish PDU ───────────────────────────────────────────
                  pdu = pmt.cons(meta, pmt.init_u8vector(len(data), data))
                  self.message_port_pub(pmt.intern('pdu_out'), pdu)

                  self.packet_count += 1
                  seq = (seq + 1) & 0xFFFF    # 16-bit rollover

                  # ── CSV logging ───────────────────────────────────────────
                  timestamp = (time.strftime('%Y-%m-%d %H:%M:%S') +
                               f".{int((time.time() % 1) * 1000):03d}")
                  data_hex  = ' '.join(f'{b:02X}' for b in data)

                  with open(self.log_file, 'a', newline='') as f:
                      writer = csv.writer(f)
                      writer.writerow([
                          self.packet_count,
                          timestamp,
                          self.user_id,
                          f"{wait_time:.4f}",
                          data_hex,
                          list(data)
                      ])

                  print(f"[PKT {self.packet_count:03d}] user_id={self.user_id} "
                        f"seq={seq - 1 & 0xFFFF:#06x} "
                        f"after {wait_time:.3f}s | "
                        f"first 4B: {data_hex.split()[:4]}")
    log_file: log_file1
    mean_interval: '1.6'
    packet_size: '20'
    total_packets: '3'
    user_id: '2'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass blk(gr.sync_block):\n    \"\"\"\n    Energy-Based Tag Deduplicator for ALOHA Add-Block Channel\n    ----------------------------------------------------------\n    Takes THREE inputs:\n      in0 = Add block output  (combined signal  → passed to output)\n      in1 = User 1 stream     (energy monitor only, not passed out)\n      in2 = User 2 stream     (energy monitor only, not passed out)\n\n    Detects which users are ACTUALLY transmitting based on signal\n    energy, then emits clean tags accordingly.\n    \"\"\"\n\n    # Threshold below which a stream is considered silent\n    ENERGY_THRESHOLD = 1e-6\n\n    def __init__(self, packet_samples=34079):\n        gr.sync_block.__init__(\n            self,\n            name=\"aloha_tag_dedup\",\n            in_sig=[np.complex64,   # in0: Add output  → goes to out\n                    np.complex64,   # in1: User 1 raw stream\n                    np.complex64],  # in2: User 2 raw stream\n            out_sig=[np.complex64]\n        )\n        self.packet_samples = packet_samples\n        self.set_tag_propagation_policy(gr.TPP_DONT)  # block all auto tags\n\n    def _stream_has_energy(self, samples):\n        \"\"\"Returns True if stream has actual packet data (non-silence).\"\"\"\n        power = np.mean(np.abs(samples) ** 2)\n        return power > self.ENERGY_THRESHOLD\n\n    def work(self, input_items, output_items):\n        combined = input_items[0]   # Add block output\n        user1    = input_items[1]   # User 1 raw\n        user2    = input_items[2]   # User 2 raw\n\n        output_items[0][:] = combined  # pass combined signal through\n\n        # ── Get packet_len tags from the combined stream ────────────\n        tags = self.get_tags_in_window(\n            0, 0, len(combined), pmt.intern(\"packet_len\")\n        )\n\n        for tag in tags:\n            offset = tag.offset\n\n            # Window of samples around this tag in each user stream\n            # (relative to this work() call's starting offset)\n            abs_start = self.nitems_written(0)\n            rel_offset = offset - abs_start\n\n            # Slice packet window from each user's stream\n            start = rel_offset\n            end   = min(rel_offset + self.packet_samples, len(user1))\n\n            u1_active = self._stream_has_energy(user1[start:end])\n            u2_active = self._stream_has_energy(user2[start:end])\n\n            # ── Decision ───────────────────────────────────────────\n            if u1_active and u2_active:\n                # COLLISION — emit single packet_len tag\n                # RX will attempt decode → CRC will fail → correct\n                self.add_item_tag(0, offset, tag.key, tag.value)\n                print(f\"[TagDedup] offset={offset} → COLLISION \"\n                      f\"(both users active) — 1 tag emitted, CRC will fail\")\n\n            elif u1_active:\n                # Only User 1 — emit clean tags\n                self.add_item_tag(0, offset, tag.key, tag.value)\n                self._copy_user_tags(0, offset)\n                print(f\"[TagDedup] offset={offset} → User 1 only — clean\")\n\n            elif u2_active:\n                # Only User 2 — emit clean tags\n                self.add_item_tag(0, offset, tag.key, tag.value)\n                self._copy_user_tags(1, offset)\n                print(f\"[TagDedup] offset={offset} → User 2 only — clean\")\n\n            else:\n                # Neither active — silence, no tag needed\n                print(f\"[TagDedup] offset={offset} → silence, tag dropped\")\n\n        return len(combined)\n\n    def _copy_user_tags(self, port, offset):\n        \"\"\"Copy user_id and seq_num tags from a specific input port.\"\"\"\n        for key in [\"user_id\", \"seq_num\", \"tx_time\"]:\n            tags = self.get_tags_in_window(\n                port, 0,\n                len(self.input_items[port]),   # full window\n                pmt.intern(key)\n            )\n            for t in tags:\n                if t.offset == offset:\n                    self.add_item_tag(0, offset, t.key, t.value)\n\"\"\"\n### Updated Flowgraph\n\nf_samp1 ──► iq_logger ──┬──────────────────────────────► in1 (energy monitor)\n                         │                                      │\n                         ├──► Add ──► in0 [aloha_tag_dedup] ──► out ──► ZMQ PUB\n                         │                    ▲\nf_samp2 ──► iq_logger ──┴──────────────────► in2 (energy monitor)\n\n\n### What Changes Per Scenario\n\nSlot where only User 1 transmits:\n  u1_active = True  (high energy)\n  u2_active = False (near-zero energy)\n  → emit packet_len + user_id=1 + seq_num=N\n  → RX decodes → CRC passes ✓\n\nSlot where only User 2 transmits:\n  u1_active = False\n  u2_active = True\n  → emit packet_len + user_id=2 + seq_num=M\n  → RX decodes → CRC passes ✓\n\nSlot where both transmit (collision):\n  u1_active = True\n  u2_active = True\n  → emit single packet_len only (no user identity)\n  → RX attempts decode → CRC FAILS → packet lost ✓\n\nSilence slot:\n  u1_active = False\n  u2_active = False\n  → no tag emitted ✓\n\"\"\"\n\n"
    packet_samples: '34079'
  states: {state: disabled}
- name: epy_block_3_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      class blk(gr.sync_block):
          def __init__(self, user_id=0, samp_rate=48000):
              gr.sync_block.__init__(
                  self,
                  name="seq_tagger",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.samp_rate       = samp_rate
              self.last_tag_offset = None
              self.set_tag_propagation_policy(gr.TPP_ALL_TO_ALL)

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              out[:] = inp

              tags = self.get_tags_in_window(
                  0, 0, len(inp),
                  pmt.intern("packet_len")
              )

              for tag in tags:
                  offset = tag.offset

                  if self.last_tag_offset is not None:
                      measured = offset - self.last_tag_offset
                      # print(f"Measured packet_samples = {measured}")

                  self.last_tag_offset = offset

                  now = time.time()
                  self.add_item_tag(
                      0, offset,
                      pmt.intern("rx_time"),
                      pmt.from_double(now)
                  )
                  print(f"[seq_tagger] PKT offset={offset} rx_time={now:.6f}")

              return len(inp)
    samp_rate: usrp_rate
    user_id: user_id1
  states: {}
- name: epy_block_3_0_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      class blk(gr.sync_block):
          def __init__(self, user_id=0, samp_rate=48000):
              gr.sync_block.__init__(
                  self,
                  name="seq_tagger",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.samp_rate       = samp_rate
              self.last_tag_offset = None
              self.set_tag_propagation_policy(gr.TPP_ALL_TO_ALL)

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              out[:] = inp

              tags = self.get_tags_in_window(
                  0, 0, len(inp),
                  pmt.intern("packet_len")
              )

              for tag in tags:
                  offset = tag.offset

                  if self.last_tag_offset is not None:
                      measured = offset - self.last_tag_offset
                      # print(f"Measured packet_samples = {measured}")

                  self.last_tag_offset = offset

                  now = time.time()
                  self.add_item_tag(
                      0, offset,
                      pmt.intern("rx_time"),
                      pmt.from_double(now)
                  )
                  print(f"[seq_tagger] PKT offset={offset} rx_time={now:.6f}")

              return len(inp)
    samp_rate: usrp_rate
    user_id: user_id2
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nimport pmt\nfrom gnuradio import gr\n\nclass nonblocking_add(gr.basic_block):\n    \"\"\"\n    Drop-in replacement for the Add block in the channel flowgraph.\n    Uses gr.basic_block + forecast(0) so it never stalls waiting\n    for a bursty input. Whichever TX stream has no samples gets\n    zero-substituted for that work() call.\n    \"\"\"\n    def __init__(self, vlen=1):\n        gr.basic_block.__init__(self,\n            name=\"nonblocking_add\",\n            in_sig=[np.complex64, np.complex64],\n            out_sig=[np.complex64])\n        self.vlen = vlen\n\n    def forecast(self, noutput_items, ninput_items_required):\n        # *** KEY: declare 0 required from both inputs ***\n        # The scheduler will NOT block waiting for either stream.\n        # We handle the \"nothing available\" case in general_work.\n        for i in range(len(ninput_items_required)):\n            ninput_items_required[i] = 0\n\n    def general_work(self, input_items, output_items):\n        avail0 = len(input_items[0])   # samples available from TX1\n        avail1 = len(input_items[1])   # samples available from TX2\n        n_out  = len(output_items[0])  # space in output buffer\n\n        # How many samples can we produce this call?\n        # Take as many as the richer stream offers, capped by output space.\n        # If both are empty we produce nothing — scheduler will retry.\n        n = min(n_out, max(avail0, avail1))\n        if n == 0:\n            return 0   # both streams idle; yield back to scheduler\n\n        # Build TX1 contribution\n        if avail0 >= n:\n            sig0 = np.array(input_items[0][:n], dtype=np.complex64)\n            self.consume(0, n)\n        elif avail0 > 0:\n            # Partial data from TX1 — pad the rest with zeros\n            sig0 = np.zeros(n, dtype=np.complex64)\n            sig0[:avail0] = input_items[0][:avail0]\n            self.consume(0, avail0)\n        else:\n            # TX1 completely idle this call\n            sig0 = np.zeros(n, dtype=np.complex64)\n            # consume(0, 0) — nothing to consume\n\n        # Build TX2 contribution\n        if avail1 >= n:\n            sig1 = np.array(input_items[1][:n], dtype=np.complex64)\n            self.consume(1, n)\n        elif avail1 > 0:\n            sig1 = np.zeros(n, dtype=np.complex64)\n            sig1[:avail1] = input_items[1][:avail1]\n            self.consume(1, avail1)\n        else:\n            sig1 = np.zeros(n, dtype=np.complex64)\n\n        output_items[0][:n] = sig0 + sig1\n        return n\n    \n\"\"\"\n## Wiring in GRC (Image 2 change)\n\nRemove the existing `Add` block. Place `nonblocking_add` in its position:\n\nVirtual Source (f_samp1) ──> iq_logger (badd1) ──┐\n                                                   ├──> nonblocking_add ──> Throttle ──> iq_logger (Aadd) ──> ZMQ PUB\nVirtual Source (f_samp2) ──> iq_logger (badd2) ──┘\n\"\"\"\n\n"
    vlen: '1'
  states: {state: disabled}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      import random
      import pmt
      from gnuradio import gr

      class stream_randomizer(gr.sync_block):
          def __init__(self, sample_rate=768000, mean_interval_ms=100.0):
              gr.sync_block.__init__(
                  self,
                  name="stream_randomizer",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.sample_rate = sample_rate
              self.mean_interval_ms = mean_interval_ms          # mean of exponential distribution

              self._pad_remaining = 0
              self._in_packet = False
              self._pkt_remaining = 0
              self._abs_offset = 0

              self.set_tag_propagation_policy(gr.TPP_DONT)

          def _draw_gap_samples(self):
              """Draw gap from Exp(1/mean) and convert to samples."""
              gap_ms = random.expovariate(1.0 / self.mean_interval_ms)
              return int(gap_ms * self.sample_rate / 1000.0)

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              nout = len(out)
              n_written = 0
              n_consumed = 0

              tags = self.get_tags_in_window(0, 0, len(in0), pmt.intern("packet_len"))

              while n_written < nout:
                  if self._in_packet and self._pkt_remaining > 0:
                      available = len(in0) - n_consumed
                      chunk = min(self._pkt_remaining, nout - n_written, available)
                      if chunk == 0:
                          break
                      out[n_written:n_written + chunk] = in0[n_consumed:n_consumed + chunk]
                      self._pkt_remaining -= chunk
                      n_written += chunk
                      n_consumed += chunk
                      if self._pkt_remaining == 0:
                          self._in_packet = False

                  else:
                      current_abs = self._abs_offset + n_consumed
                      remaining_tags = [t for t in tags if t.offset >= current_abs]
                      if not remaining_tags:
                          n_consumed = len(in0)
                          break
                      tag = remaining_tags[0]
                      pkt_len = pmt.to_long(tag.value)
                      self._in_packet = True
                      self._pkt_remaining = pkt_len
                      skip = int(tag.offset - current_abs)
                      n_consumed += skip

              self._abs_offset += n_consumed
              self.consume(0, n_consumed)
              return n_written
    mean_interval_ms: '5'
    sample_rate: usrp_rate
  states: {state: disabled}
- name: epy_block_5_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nimport random\nimport pmt\nfrom gnuradio import gr\n\nclass stream_randomizer(gr.sync_block):\n    \"\"\"\n    Inserts random zero-padding before each packet in the stream domain.\n    Input:  tagged stream of complex modulated samples (packet_len tagged)\n    Output: continuous stream with random silence gaps between packets\n    \"\"\"\n    def __init__(self, sample_rate=768000, min_gap_ms=5, max_gap_ms=50):\n        gr.sync_block.__init__(\n            self,\n            name=\"stream_randomizer\",\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        self.sample_rate = sample_rate\n        self.min_gap = int(min_gap_ms * sample_rate / 1000)\n        self.max_gap = int(max_gap_ms * sample_rate / 1000)\n\n        # Internal state\n        self._pad_remaining = 0       # zeros still to emit\n        self._in_packet = False       # currently forwarding packet samples?\n        self._pkt_remaining = 0       # packet samples left to forward\n\n        self.set_tag_propagation_policy(gr.TPP_DONT)  # suppress old tags\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        out = output_items[0]\n        nout = len(out)\n        n_written = 0\n        n_consumed = 0\n\n        tags = self.get_tags_in_window(0, 0, len(in0), pmt.intern(\"packet_len\"))\n\n        while n_written < nout:\n            if self._pad_remaining > 0:\n                # Emit zeros for the random delay\n                chunk = min(self._pad_remaining, nout - n_written)\n                out[n_written:n_written + chunk] = 0 + 0j\n                self._pad_remaining -= chunk\n                n_written += chunk\n\n            elif self._in_packet and self._pkt_remaining > 0:\n                # Forward actual packet samples\n                available = len(in0) - n_consumed\n                chunk = min(self._pkt_remaining, nout - n_written, available)\n                if chunk == 0:\n                    break\n                out[n_written:n_written + chunk] = in0[n_consumed:n_consumed + chunk]\n                self._pkt_remaining -= chunk\n                n_written += chunk\n                n_consumed += chunk\n                if self._pkt_remaining == 0:\n                    self._in_packet = False\n\n            else:\n                # Look for next packet_len tag\n                remaining_tags = [t for t in tags if t.offset >= self._nitems_read(0) + n_consumed]\n                if not remaining_tags:\n                    # No more packets in this buffer — consume remainder, emit zeros\n                    n_consumed = len(in0)\n                    break\n                tag = remaining_tags[0]\n                pkt_len = pmt.to_long(tag.value)\n                # Schedule: random gap THEN packet\n                gap = random.randint(self.min_gap, self.max_gap)\n                self._pad_remaining = gap\n                self._in_packet = True\n                self._pkt_remaining = pkt_len\n                # Skip input samples up to tag offset\n                skip = int(tag.offset - (self._nitems_read(0) + n_consumed))\n                n_consumed += skip\n\n        self.consume(0, n_consumed)\n        return n_written\n\n\"\"\"\n## Flowgraph Placement\n\n[Packet Source]\n      ↓\n[CRC32 Append]\n      ↓\n[Protocol Formatter]\n      ↓\n[PDU to Tagged Stream]\n      ↓\n[Chunks to Symbols / Repack]\n      ↓\n[DBPSK Mod]\n      ↓\n[stream_randomizer EPB]   ← INSERT HERE (after mod, before ZMQ)\n      ↓\n[ZMQ PUSH Sink]\n\n\"\"\"\n\n"
    max_gap_ms: '45'
    min_gap_ms: '0'
    sample_rate: usrp_rate
  states: {state: disabled}
- name: epy_block_6
  id: epy_block
  parameters:
    T0: ''
    _source_code: |-
      """
      zero_pad_inserter — corrected EPB for GNU Radio ALOHA simulation
      ================================================================

      PURPOSE
      -------
      Converts a back-to-back packet stream (output of the TX modulator chain)
      into a time-stamped stream where each packet begins at its correct absolute
      sample position.  When two such streams are fed into a GNU Radio `Add` block
      the result correctly models ALOHA collision semantics:
        - overlapping packets are summed (collision)
        - non-overlapping packets appear at their true positions (no spurious sum)

      KEY FIX vs original
      -------------------
      Old code:  drew a *random exponential gap* before each packet → wrong positions
      New code:  computes pad = (rx_time − T0) × samp_rate − abs_out_offset

      SHARED T0 REQUIREMENT
      ---------------------
      Every zero_pad_inserter instance in the flowgraph **must** receive the same
      T0 value.  Pass it as a constructor argument, e.g.:

          inserter_tx1 = zero_pad_inserter(samp_rate=768e3, T0=shared_epoch)
          inserter_tx2 = zero_pad_inserter(samp_rate=768e3, T0=shared_epoch)

      If T0 is None the first instance that sees a packet establishes the epoch and
      you must propagate that value to all other instances before their first
      packet arrives (use a message port or a shared module-level variable).

      TAGS EXPECTED ON INBOUND STREAM
      --------------------------------
      At the same sample offset for each packet:
        • "packet_len"  (long)   — number of samples in the packet body
        • "rx_time"     (double) — absolute transmission time in seconds (epoch-free)
                                   Produced by seq_tagger / Random_Packet_Generator.

      VERIFIED AGAINST
      ----------------
      CSV data (iq_badd1, iq_badd2, iq_Aadd) from 2026-03-19 run:
        TX1 Pkt1 (isolated)   → no collision  ✓
        TX1 Pkt2 vs TX2 Pkt1 → 18 823 samples collision (24.5 ms)  ✓
        TX1 Pkt3 vs TX2 Pkt2 → 18 957 samples collision (24.7 ms)  ✓
      """

      import numpy as np
      import pmt
      import gnuradio.gr as gr


      class zero_pad_inserter(gr.sync_block):
          # Use gr.basic_block if this is message-only; sync_block for stream I/O.

          def __init__(self, samp_rate: float = 768_000.0, T0: float = None):
              gr.sync_block.__init__(
                  self,
                  name="zero_pad_inserter",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64],
              )
              self._samp_rate     = float(samp_rate)
              self._T0            = T0          # absolute epoch in seconds; None → auto

              # ── mutable state ────────────────────────────────────────────────────
              self._abs_in_offset  = 0   # total input  samples consumed so far
              self._abs_out_offset = 0   # total output samples produced so far

              self._pad_remaining  = 0   # zeros still to emit before current packet
              self._in_packet      = False
              self._pkt_remaining  = 0   # packet body samples still to copy

          # ── helpers ──────────────────────────────────────────────────────────────

          def _build_rx_time_map(self, in_len: int) -> dict:
              """Return {abs_offset: rx_time_seconds} for all rx_time tags in window."""
              result = {}
              for t in self.get_tags_in_window(0, 0, in_len, pmt.intern("rx_time")):
                  result[t.offset] = pmt.to_double(t.value)
              return result

          # ── main work function ───────────────────────────────────────────────────

          def work(self, input_items, output_items):
              in0  = input_items[0]
              out  = output_items[0]
              nout = len(out)
              n_written  = 0
              n_consumed = 0

              # Fetch all packet_len tags and rx_time tags in this window once.
              plen_tags  = self.get_tags_in_window(
                  0, 0, len(in0), pmt.intern("packet_len"))
              rx_time_map = self._build_rx_time_map(len(in0))

              while n_written < nout:

                  # ── Phase 1: drain pending zero-pad ─────────────────────────────
                  if self._pad_remaining > 0:
                      chunk = min(self._pad_remaining, nout - n_written)
                      out[n_written : n_written + chunk] = 0 + 0j
                      self._pad_remaining   -= chunk
                      n_written             += chunk
                      self._abs_out_offset  += chunk
                      continue

                  # ── Phase 2: copy packet body ────────────────────────────────────
                  if self._in_packet and self._pkt_remaining > 0:
                      available = len(in0) - n_consumed
                      chunk = min(self._pkt_remaining, nout - n_written, available)
                      if chunk == 0:
                          break
                      out[n_written : n_written + chunk] = in0[n_consumed : n_consumed + chunk]
                      self._pkt_remaining   -= chunk
                      n_written             += chunk
                      n_consumed            += chunk
                      self._abs_out_offset  += chunk
                      if self._pkt_remaining == 0:
                          self._in_packet = False
                      continue

                  # ── Phase 3: locate next packet_len tag ─────────────────────────
                  current_abs = self._abs_in_offset + n_consumed
                  upcoming = [t for t in plen_tags if t.offset >= current_abs]
                  if not upcoming:
                      n_consumed = len(in0)
                      break

                  tag     = upcoming[0]
                  pkt_len = pmt.to_long(tag.value)

                  # ── Compute absolute sample target from rx_time ──────────────────
                  if tag.offset not in rx_time_map:
                      # Missing rx_time tag — upstream configuration error.
                      raise RuntimeError(
                          f"zero_pad_inserter: no rx_time tag at offset {tag.offset}. "
                          f"Available rx_time offsets: {sorted(rx_time_map.keys())}. "
                          f"Ensure seq_tagger emits rx_time alongside packet_len."
                      )

                  rx_time_sec = rx_time_map[tag.offset]

                  if self._T0 is None:
                      # Auto-establish epoch from first packet seen.
                      # WARNING: all inserter instances must end up with the same T0.
                      # Pass T0 explicitly in the constructor to avoid this race.
                      self._T0 = rx_time_sec

                  target = int((rx_time_sec - self._T0) * self._samp_rate)

                  # ── Sanity: output must not go backward ──────────────────────────
                  pad = target - self._abs_out_offset
                  if pad < 0:
                      raise RuntimeError(
                          f"zero_pad_inserter: negative pad ({pad:,}) at tag offset "
                          f"{tag.offset}.  rx_time={rx_time_sec:.6f}  T0={self._T0:.6f}  "
                          f"target={target:,}  abs_out={self._abs_out_offset:,}.  "
                          f"Possible causes: out-of-order packets, wrong T0, or "
                          f"sample-rate mismatch."
                      )

                  # ── Skip inter-tag input samples (should be 0 in normal use) ────
                  skip = int(tag.offset - current_abs)
                  assert skip >= 0
                  if skip > 0:
                      # Samples exist in the input stream between packets.
                      # These are not packet data — silently consume them but do NOT
                      # advance abs_out_offset (they produce no output).
                      n_consumed += skip

                  self._pad_remaining = pad
                  self._in_packet     = True
                  self._pkt_remaining = pkt_len
                  # Loop back to Phase 1 to start emitting zeros.

              self._abs_in_offset += n_consumed
              self.consume(0, n_consumed)
              return n_written
    samp_rate: usrp_rate
  states: {state: disabled}
- name: epy_block_7
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import queue

      class blk(gr.basic_block):
          """
          PDU Passthrough — accepts PDU burst from Tagged Stream to PDU,
          outputs the raw IQ samples as a stream. No zero-padding, no ALOHA logic.
          Use this to verify PDU → stream conversion is working correctly.
          """

          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="PDU Passthrough",
                  in_sig=[],
                  out_sig=[np.complex64]
              )
              self.message_port_register_in(pmt.intern("burst_in"))
              self.set_msg_handler(pmt.intern("burst_in"), self._handle_pdu)

              self._queue        = queue.Queue()
              self._burst        = None
              self._burst_offset = 0

          def _handle_pdu(self, msg):
              try:
                  payload = pmt.cdr(msg)
                  samples = np.array(pmt.c32vector_elements(payload), dtype=np.complex64)
                  self._queue.put(samples)
                  print(f"[PDU Passthrough] received burst: {len(samples)} samples")
              except Exception as e:
                  print(f"[PDU Passthrough] error: {e}")

          def general_work(self, input_items, output_items):
              out      = output_items[0]
              n_out    = len(out)
              produced = 0

              while produced < n_out:
                  if self._burst is None:
                      try:
                          self._burst        = self._queue.get_nowait()
                          self._burst_offset = 0
                      except queue.Empty:
                          out[produced:n_out] = np.complex64(0)
                          produced = n_out
                          break

                  burst_remaining = len(self._burst) - self._burst_offset
                  space_left      = n_out - produced
                  n_copy          = min(burst_remaining, space_left)

                  out[produced : produced + n_copy] = \
                      self._burst[self._burst_offset : self._burst_offset + n_copy]

                  self._burst_offset += n_copy
                  produced           += n_copy

                  if self._burst_offset >= len(self._burst):
                      self._burst        = None
                      self._burst_offset = 0

              return produced
  states: {}
- name: epy_block_7_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import queue

      class blk(gr.basic_block):
          """
          PDU Passthrough — accepts PDU burst from Tagged Stream to PDU,
          outputs the raw IQ samples as a stream. No zero-padding, no ALOHA logic.
          Use this to verify PDU → stream conversion is working correctly.
          """

          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="PDU Passthrough",
                  in_sig=[],
                  out_sig=[np.complex64]
              )
              self.message_port_register_in(pmt.intern("burst_in"))
              self.set_msg_handler(pmt.intern("burst_in"), self._handle_pdu)

              self._queue        = queue.Queue()
              self._burst        = None
              self._burst_offset = 0

          def _handle_pdu(self, msg):
              try:
                  payload = pmt.cdr(msg)
                  samples = np.array(pmt.c32vector_elements(payload), dtype=np.complex64)
                  self._queue.put(samples)
                  print(f"[PDU Passthrough] received burst: {len(samples)} samples")
              except Exception as e:
                  print(f"[PDU Passthrough] error: {e}")

          def general_work(self, input_items, output_items):
              out      = output_items[0]
              n_out    = len(out)
              produced = 0

              while produced < n_out:
                  if self._burst is None:
                      try:
                          self._burst        = self._queue.get_nowait()
                          self._burst_offset = 0
                      except queue.Empty:
                          out[produced:n_out] = np.complex64(0)
                          produced = n_out
                          break

                  burst_remaining = len(self._burst) - self._burst_offset
                  space_left      = n_out - produced
                  n_copy          = min(burst_remaining, space_left)

                  out[produced : produced + n_copy] = \
                      self._burst[self._burst_offset : self._burst_offset + n_copy]

                  self._burst_offset += n_copy
                  produced           += n_copy

                  if self._burst_offset >= len(self._burst):
                      self._burst        = None
                      self._burst_offset = 0

              return produced
  states: {}
- name: fft_filter_xxx_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: iq1_1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_samplesTX1.csv
  states: {}
- name: iq1_2
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_badd1.csv
  states: {}
- name: iq2_1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_samplesTX2.csv
  states: {}
- name: iq2_2
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_badd2.csv
  states: {}
- name: iq_add
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_Aadd.csv
  states: {}
- name: log_file1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: data_tx1.csv
  states: {}
- name: log_file2
  id: parameter
  parameters:
    label: File Name
    type: str
    value: data_tx2.csv
  states: {}
- name: mmse_resampler_xx_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 1.0/((usrp_rate/samp_rate)*rs_ratio)
    type: complex
  states: {}
- name: mmse_resampler_xx_0_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 1.0  / ( ( usrp_rate / samp_rate ) * rs_ratio )
    type: complex
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,3
    gui_hint: 1,0,1,3
    label1: ''
    name: Transmit data 1
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,3
    gui_hint: 2,0,1,3
    label1: ''
    name: Transmit data 2
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: timestamp1_1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: timestamps1_1.txt
  states: {}
- name: timestamp1_2
  id: parameter
  parameters:
    label: File Name
    type: str
    value: timestampsTx1_2.txt
  states: {}
- name: timestamp2_1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: timestamps2_1.txt
  states: {}
- name: timestamp2_2
  id: parameter
  parameters:
    label: File Name
    type: str
    value: timestampsTx2_2.txt
  states: {}
- name: timestamp_add
  id: parameter
  parameters:
    label: File Name
    type: str
    value: timestamp_add.txt
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: t2
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: f_samp2
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: f_samp1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: t1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: t2
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: f_samp1
  states: {state: disabled}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: f_samp1
  states: {}
- name: virtual_source_1_1_0
  id: virtual_source
  parameters:
    stream_id: f_samp2
  states: {}
- name: virtual_source_1_1_1
  id: virtual_source
  parameters:
    stream_id: f_samp1
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49203
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49203
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_pub_sink_0_1
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49203
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:49203
    bind: 'False'
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_uchar_to_float_0_0_0_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', blocks_uchar_to_float_0_0_0_0_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_multiply_length_1, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', virtual_sink_0_0_0, '0']
- [blocks_throttle2_0, '0', epy_block_1_0_0_1, '0']
- [blocks_throttle2_0_0, '0', epy_block_1_0, '0']
- [blocks_throttle2_0_1, '0', zeromq_pub_sink_0_1, '0']
- [blocks_uchar_to_float_0_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_0_0_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_file_meta_sink_0, '0']
- [digital_constellation_modulator_0, '0', epy_block_1, '0']
- [digital_constellation_modulator_0_0, '0', blocks_file_meta_sink_0_0, '0']
- [digital_constellation_modulator_0_0, '0', epy_block_1_1, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [digital_crc32_bb_0_0, '0', digital_protocol_formatter_bb_0_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_protocol_formatter_bb_0_0, '0', blocks_tagged_stream_mux_0_0, '0']
- [epy_block_0, '0', digital_crc32_bb_0, '0']
- [epy_block_0_0, '0', digital_crc32_bb_0_0, '0']
- [epy_block_1, '0', fft_filter_xxx_0_0_0, '0']
- [epy_block_1_0, '0', zeromq_pub_sink_0_0, '0']
- [epy_block_1_0, '0', zeromq_push_sink_0, '0']
- [epy_block_1_0_0, '0', blocks_add_xx_0, '0']
- [epy_block_1_0_0, '0', epy_block_4, '0']
- [epy_block_1_0_0_0, '0', blocks_add_xx_0, '1']
- [epy_block_1_0_0_0, '0', epy_block_4, '1']
- [epy_block_1_0_0_1, '0', zeromq_pub_sink_0, '0']
- [epy_block_1_0_0_2, '0', blocks_throttle2_0_1, '0']
- [epy_block_1_1, '0', fft_filter_xxx_0_0_0_0, '0']
- [epy_block_2, pdu_out, blocks_message_debug_0, print]
- [epy_block_2, pdu_out, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_2_1, pdu_out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [epy_block_3_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [epy_block_3_0_1, '0', blocks_tag_debug_0_0, '0']
- [epy_block_3_0_1, '0', blocks_tagged_stream_multiply_length_1, '0']
- [epy_block_4, '0', blocks_throttle2_0, '0']
- [epy_block_5, '0', virtual_sink_0_1, '0']
- [epy_block_7, '0', blocks_tag_debug_0, '0']
- [epy_block_7, '0', virtual_sink_0_1_0, '0']
- [epy_block_7_0, '0', virtual_sink_0_1, '0']
- [fft_filter_xxx_0_0_0, '0', mmse_resampler_xx_0_0_0, '0']
- [fft_filter_xxx_0_0_0_0, '0', mmse_resampler_xx_0_0, '0']
- [mmse_resampler_xx_0_0, '0', epy_block_3_0_1, '0']
- [mmse_resampler_xx_0_0, '0', epy_block_5, '0']
- [mmse_resampler_xx_0_0_0, '0', epy_block_3_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', digital_crc32_bb_0_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_7, burst_in]
- [pdu_tagged_stream_to_pdu_0_0, pdus, epy_block_7_0, burst_in]
- [virtual_source_0, '0', blocks_repack_bits_bb_0_0, '0']
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_0_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [virtual_source_0_0, '0', digital_constellation_modulator_0_0, '0']
- [virtual_source_1, '0', blocks_throttle2_0_0, '0']
- [virtual_source_1_1, '0', epy_block_1_0_0, '0']
- [virtual_source_1_1_0, '0', epy_block_1_0_0_0, '0']
- [virtual_source_1_1_1, '0', epy_block_1_0_0_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
