options:
  parameters:
    author: venka
    generate_options: qt_gui
    id: TX_1
    output_language: python
    title: 1TX
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''1010101010101010101010101010101011100001010110101110100010010011'''
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: bw
  id: variable
  parameters:
    value: (1+excess_bw)*(samp_rate//sps)
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Offset
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: (bw//2)+5e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    label: Noise Voltage
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.0'
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_0
  id: variable_qtgui_chooser
  parameters:
    label: Sample rate
    num_opts: '2'
    option0: '768000'
    option1: '576000'
    type: int
    value: '768000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0 + 0.0j, ]'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    label: Timing Offset
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.000'
  states: {}
- name: user_id1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: user_id2
  id: variable
  parameters:
    value: '2'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: addr1
  id: parameter
  parameters:
    label: tcp
    type: str
    value: tcp://127.0.0.1:49212
  states: {}
- name: addr2
  id: parameter
  parameters:
    label: tcp
    type: str
    value: tcp://127.0.0.1:49213
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: tx1
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: sps*8
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: taps
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      #!/usr/bin/env python
      from gnuradio import gr
      import numpy as np
      import time
      import csv

      class iq_logger_with_timestamp(gr.sync_block):
          def __init__(self, iq_csv_filename="iq_samples.csv"):
              gr.sync_block.__init__(
                  self,
                  name="iq_logger_with_timestamp",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.iq_csv_filename = iq_csv_filename
              self.sample_count = 0

              # Initialize CSV with header (same pattern as Random_Packet_Generator)
              with open(self.iq_csv_filename, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'sample_index',
                      'timestamp',
                      'num_samples',
                      'i_values',
                      'q_values'
                  ])

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              # Timestamp with millisecond precision (matches Random_Packet_Generator style)
              timestamp = time.strftime('%Y-%m-%d %H:%M:%S') + \
                          f".{int((time.time() % 1) * 1000):03d}"

              num_samples = len(in0)

              # Split complex64 into separate I and Q lists
              i_values = in0.real.tolist()
              q_values = in0.imag.tolist()

              # Append row to CSV
              with open(self.iq_csv_filename, 'a', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      self.sample_count,
                      timestamp,
                      num_samples,
                      i_values,
                      q_values
                  ])

              self.sample_count += num_samples

              # Pass samples through unchanged
              out0[:] = in0
              return len(out0)

          def stop(self):
              print(f"[IQ Logger] Finished. Total samples logged: {self.sample_count}")
              return True
    iq_csv_filename: iq1_1
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import random
      import time
      import threading
      import csv

      class Random_Packet_Generator(gr.basic_block):
          """
          Random Packet Generator with embedded userid and sequence number.

          Packet payload layout:
              [0:2]  – seq_num  : 2 bytes, big-endian uint16
              [2:4]  – user_id  : 2 bytes, big-endian uint16  (0–65535)
              [4:]   – random data : fills the rest up to packet_size bytes

          The PMT metadata dict carries:
              'packet_num' → seq_num  (used by Packet Header Generator block)
              'user_id'    → user_id  (informational)
          """

          def __init__(self,
                       mean_interval=0.1,
                       packet_size=100,
                       user_id=1,
                       log_file="transmitted_packets.csv", 
                       total_packets=10,
                       initial_delay=2.0): # 1. ADDED: initial_delay parameter

              gr.basic_block.__init__(self,
                  name="random_packet_generator",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_out(pmt.intern('pdu_out'))

              # ── Parameters ────────────────────────────────────────────────
              self.mean_interval = mean_interval
              self.packet_size   = packet_size
              self.user_id       = int(user_id) & 0xFFFF   # clamp to uint16
              self.log_file      = log_file
              self.total_packets = total_packets
              self.initial_delay = initial_delay           # 2. ADDED: store delay attribute

              self.packet_count  = 0

              # Header overhead: seq(2) + user_id(2) = 4 bytes
              if packet_size <= 4:
                  raise ValueError(
                      f"packet_size ({packet_size}) must be > 4 to fit the header"
                  )

              # ── Init CSV log ──────────────────────────────────────────────
              with open(self.log_file, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'packet_id', 'timestamp', 'user_id',
                      'wait_time_s', 'data_hex', 'data_bytes'
                  ])

              # ── Start generator thread ────────────────────────────────────
              self.thread = threading.Thread(target=self._generate_packets, daemon=True)
              self.thread.start()

          # ─────────────────────────────────────────────────────────────────
          def _build_payload(self, seq: int) -> list:
              """
              Assemble the byte payload:
                  [seq_hi, seq_lo, uid_hi, uid_lo, *random_bytes]
              """
              header = [
                  (seq          >> 8) & 0xFF,   # seq high byte
                   seq                & 0xFF,   # seq low byte
                  (self.user_id >> 8) & 0xFF,   # user_id high byte
                   self.user_id       & 0xFF,   # user_id low byte
              ]
              random_bytes = [random.randint(0, 255)
                              for _ in range(self.packet_size - len(header))]
              return header + random_bytes

          # ─────────────────────────────────────────────────────────────────
          def _generate_packets(self):
              seq = 0
              
              # 3. ADDED: Force a hard wait before starting the packet generation loop
              print(f"[Random_Packet_Generator TX{self.user_id}] Waiting {self.initial_delay}s for hardware warmup...")
              time.sleep(self.initial_delay)
              
              # Keep the random stagger so multiple TX blocks don't start at the exact same millisecond
              time.sleep(random.uniform(0, self.mean_interval))
              
              while self.packet_count < self.total_packets:
                  wait_time = random.expovariate(1.0 / self.mean_interval)
                  time.sleep(wait_time)

                  data = self._build_payload(seq)

                  # ── Build PMT metadata dict ───────────────────────────────
                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta,
                                      pmt.intern('packet_num'),
                                      pmt.from_long(seq))             # Packet Header Generator
                  meta = pmt.dict_add(meta,
                                      pmt.intern('user_id'),
                                      pmt.from_long(self.user_id))    # informational

                  # ── Publish PDU ───────────────────────────────────────────
                  pdu = pmt.cons(meta, pmt.init_u8vector(len(data), data))
                  self.message_port_pub(pmt.intern('pdu_out'), pdu)

                  self.packet_count += 1
                  seq = (seq + 1) & 0xFFFF    # 16-bit rollover

                  # ── CSV logging ───────────────────────────────────────────
                  timestamp = (time.strftime('%Y-%m-%d %H:%M:%S') +
                               f".{int((time.time() % 1) * 1000):03d}")
                  data_hex  = ' '.join(f'{b:02X}' for b in data)

                  with open(self.log_file, 'a', newline='') as f:
                      writer = csv.writer(f)
                      writer.writerow([
                          self.packet_count,
                          timestamp,
                          self.user_id,
                          f"{wait_time:.4f}",
                          data_hex,
                          list(data)
                      ])

                  print(f"[PKT {self.packet_count:03d}] user_id={self.user_id} "
                        f"seq={seq - 1 & 0xFFFF:#06x} "
                        f"after {wait_time:.3f}s | "
                        f"first 4B: {data_hex.split()[:4]}")
    initial_delay: '3'
    log_file: log_file1
    mean_interval: '1.6'
    packet_size: '20'
    total_packets: '3'
    user_id: '1'
  states: {}
- name: epy_block_3_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      class blk(gr.sync_block):
          def __init__(self, user_id=0, samp_rate=48000):
              gr.sync_block.__init__(
                  self,
                  name="seq_tagger",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.samp_rate       = samp_rate
              self.last_tag_offset = None
              self.set_tag_propagation_policy(gr.TPP_ALL_TO_ALL)

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              out[:] = inp

              tags = self.get_tags_in_window(
                  0, 0, len(inp),
                  pmt.intern("packet_len")
              )

              for tag in tags:
                  offset = tag.offset

                  if self.last_tag_offset is not None:
                      measured = offset - self.last_tag_offset
                      # print(f"Measured packet_samples = {measured}")

                  self.last_tag_offset = offset

                  now = time.time()
                  self.add_item_tag(
                      0, offset,
                      pmt.intern("rx_time"),
                      pmt.from_double(now)
                  )
                  print(f"[seq_tagger] PKT offset={offset} rx_time={now:.6f}")

              return len(inp)
    samp_rate: usrp_rate
    user_id: user_id1
  states: {}
- name: epy_block_7
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import queue
      import time

      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="PDU Passthrough (Verified)",
                  in_sig=[],
                  out_sig=[np.complex64],
              )
              self.message_port_register_in(pmt.intern("burst_in"))
              self.set_msg_handler(pmt.intern("burst_in"), self._handle_pdu)

              self._queue = queue.Queue()
              self._burst = None
              self._offset = 0
              self._packet_count = 0  # To verify arrival count

          def _handle_pdu(self, msg):
              try:
                  # Extract samples from PDU
                  samples = np.array(
                      pmt.c32vector_elements(pmt.cdr(msg)),
                      dtype=np.complex64,
                  )
                  self._packet_count += 1
                  self._queue.put(samples)
                  
                  # Detailed Verification Log
                  print(f"[VERIFY] Packet #{self._packet_count} received at {time.strftime('%H:%M:%S')}")
                  print(f"        Size: {len(samples)} samples")
              except Exception as e:
                  print(f"[ERROR] PDU handling failed: {e}")

          def _try_load(self):
              if self._burst is not None:
                  return
              try:
                  self._burst = self._queue.get_nowait()
                  self._offset = 0
              except queue.Empty:
                  pass 

          def general_work(self, input_items, output_items):
              out = output_items[0]
              n_out = len(out)
              self._try_load()

              if self._burst is None:
                  # Idle state: Send zeros. 
                  # Note: This is necessary for RF interference (Summing)
                  out[:] = np.complex64(0)
                  return n_out

              remaining = len(self._burst) - self._offset
              take = min(n_out, remaining)

              out[:take] = self._burst[self._offset : self._offset + take]

              if take < n_out:
                  # Fill the rest of the buffer with zeros if burst ends
                  out[take:] = np.complex64(0)

              self._offset += take
              if self._offset >= len(self._burst):
                  print(f"[VERIFY] Packet #{self._packet_count} output complete.")
                  self._burst = None
                  self._offset = 0

              return n_out
  states: {}
- name: fft_filter_xxx_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: iq1_1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_samplesTX1.csv
  states: {}
- name: iq1_2
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_badd1.csv
  states: {}
- name: iq2_1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_samplesTX2.csv
  states: {}
- name: iq2_2
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_badd2.csv
  states: {}
- name: iq_add
  id: parameter
  parameters:
    label: File Name
    type: str
    value: iq_Aadd.csv
  states: {}
- name: log_file1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: data_tx1.csv
  states: {}
- name: log_file2
  id: parameter
  parameters:
    label: File Name
    type: str
    value: data_tx2.csv
  states: {}
- name: mmse_resampler_xx_0_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 1.0  / ( ( usrp_rate / samp_rate ) * rs_ratio )
    type: complex
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,3
    gui_hint: 1,0,1,3
    label1: ''
    name: Transmit data 1
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: iq samples post pdu
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: packet_len
    type: complex
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: f_samp1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: t1
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49201
    bind: 'False'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49203
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_repack_bits_bb_0_0, '0', blocks_uchar_to_float_0_0_0_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [blocks_uchar_to_float_0_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [channels_channel_model_0, '0', zeromq_pub_sink_0, '0']
- [digital_constellation_modulator_0, '0', epy_block_1, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [epy_block_1, '0', fft_filter_xxx_0_0_0, '0']
- [epy_block_2, pdu_out, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_3_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [epy_block_3_0, '0', qtgui_time_sink_x_1, '1']
- [epy_block_7, '0', blocks_tag_debug_0, '0']
- [epy_block_7, '0', blocks_throttle2_0, '0']
- [epy_block_7, '0', qtgui_time_sink_x_1, '0']
- [epy_block_7, '0', virtual_sink_0_1_0, '0']
- [fft_filter_xxx_0_0_0, '0', mmse_resampler_xx_0_0_0, '0']
- [mmse_resampler_xx_0_0_0, '0', epy_block_3_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_7, burst_in]
- [virtual_source_0, '0', blocks_repack_bits_bb_0_0, '0']
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [zeromq_sub_source_0, '0', channels_channel_model_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
