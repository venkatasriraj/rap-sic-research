options:
  parameters:
    author: venka
    description: packet reception
    generate_options: qt_gui
    id: RX_hackRF
    output_language: python
    title: RX
  states: {}

blocks:
- name: TUNE
  id: variable_qtgui_range
  parameters:
    start: 912.5e6
    step: 0.5e6
    stop: 917.5e6
    value: 915e6
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: bw
  id: variable
  parameters:
    value: (samp_rate//sps)*(1+excess_bw)
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: fc
  id: variable
  parameters:
    value: 99.5e6
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '5'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '4'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: 2.0*(10**6)
  states: {}
- name: Infile
  id: parameter
  parameters:
    label: filename
    type: str
    value: log.txt
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '3'
    rate: '0.05'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ./output.tmp
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '''11100001010110101110100010010011'''
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: phase_bw
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '44'
    rolloff: excess_bw
    samps_per_sym: sps
    type: cc
    w: phase_bw
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import time
      import csv


      class blk(gr.basic_block):
          """
          EPB: Decode Packet

          Extracts seq_num and user_id from the fixed 4-byte payload header
          that was embedded by random_packet_generator at TX:

              byte 0-1 : seq_num  (big-endian uint16)
              byte 2-3 : user_id  (big-endian uint16)
              byte 4+  : random payload

          Logs every received packet to CSV and forwards the full PDU
          downstream (to PDU to Tagged Stream → File Sink).
          """

          def __init__(self, output_file="output.bin", log_file="rx_log.csv"):
              gr.basic_block.__init__(self,
                  name="EPB: Decode Packet",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu)

              self.log_file  = log_file
              self.rx_count  = 0

              # Initialise log file with header
              with open(self.log_file, 'w', newline='') as f:
                  csv.writer(f).writerow([
                      'rx_count', 'timestamp',
                      'user_id', 'seq_num',
                      'payload_len', 'data_hex'
                  ])

          # ------------------------------------------------------------------
          def handle_pdu(self, pdu):
              # PDU = (meta, data)  — data is the full byte vector from CRC32
              data_bytes = bytes(pmt.u8vector_elements(pmt.cdr(pdu)))

              # ── Validate minimum length ────────────────────────────────
              if len(data_bytes) < 4:
                  print(f"[RX] WARNING: packet too short ({len(data_bytes)} bytes), skipping")
                  return

              # ── Extract header fields from payload bytes ───────────────
              #    DO NOT read from PMT metadata — it is gone after demod
              seq_num = (data_bytes[0] << 8) | data_bytes[1]   # bytes 0-1
              user_id = (data_bytes[2] << 8) | data_bytes[3]   # bytes 2-3
              payload = data_bytes[4:]                          # bytes 4+

              # ── Logging ────────────────────────────────────────────────
              self.rx_count += 1
              timestamp = (time.strftime('%Y-%m-%d %H:%M:%S') +
                           f".{int((time.time() % 1) * 1000):03d}")
              data_hex  = ' '.join(f'{b:02X}' for b in data_bytes)

              print(f"[RX {self.rx_count:03d}] user_id={user_id} "
                    f"seq={seq_num:#06x} "
                    f"payload_len={len(payload)} "
                    f"| first 4B: {data_hex.split()[:4]}")

              with open(self.log_file, 'a', newline='') as f:
                  csv.writer(f).writerow([
                      self.rx_count,
                      timestamp,
                      user_id,
                      seq_num,
                      len(payload),
                      data_hex
                  ])

              # ── Forward full PDU downstream ────────────────────────────
              # Stream CRC32 (Check mode) already discarded bad packets,
              # so every packet reaching here is CRC-valid.
              self.message_port_pub(pmt.intern("pdu_out"), pdu)
    comment: |-
      Strip preamble and postamble
      Convert Base64 to original file content
    log_file: rx_log
    output_file: output_filename
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python
      from gnuradio import gr
      import numpy as np
      import time
      import csv

      class iq_logger_with_timestamp(gr.sync_block):
          def __init__(self, iq_csv_filename="iq_samples.csv"):
              gr.sync_block.__init__(
                  self,
                  name="iq_logger_with_timestamp",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.iq_csv_filename = iq_csv_filename
              self.sample_count = 0

              # Initialize CSV with header (same pattern as Random_Packet_Generator)
              with open(self.iq_csv_filename, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'sample_index',
                      'timestamp',
                      'num_samples',
                      'i_values',
                      'q_values'
                  ])

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              # Timestamp with millisecond precision (matches Random_Packet_Generator style)
              timestamp = time.strftime('%Y-%m-%d %H:%M:%S') + \
                          f".{int((time.time() % 1) * 1000):03d}"

              num_samples = len(in0)

              # Split complex64 into separate I and Q lists
              i_values = in0.real.tolist()
              q_values = in0.imag.tolist()

              # Append row to CSV
              with open(self.iq_csv_filename, 'a', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      self.sample_count,
                      timestamp,
                      num_samples,
                      i_values,
                      q_values
                  ])

              self.sample_count += num_samples

              # Pass samples through unchanged
              out0[:] = in0
              return len(out0)

          def stop(self):
              print(f"[IQ Logger] Finished. Total samples logged: {self.sample_count}")
              return True
    iq_csv_filename: iq
  states: {}
- name: iq
  id: parameter
  parameters:
    label: filename
    type: str
    value: iqRx.csv
  states: {}
- name: output_filename
  id: parameter
  parameters:
    label: file
    type: str
    value: output.bin
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: 0,2,1,2
    gui_hint: 0,2,1,2
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    comment: 0,0,1,2
    gui_hint: 0,0,1,2
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    comment: 2,2,1,2
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,2,1,2
    name: BEFORE SYMBOL SYNC
    type: complex
    wintype: window.WIN_FLATTOP
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: 2,0,1,2
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,1,2
    name: RF CHAIN O/P
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,2,1,2
    gui_hint: 1,2,1,2
    label1: ''
    name: Correlate Output
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,2
    gui_hint: 1,0,1,2
    label1: ''
    name: Correlate input
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.2'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: rx_log
  id: parameter
  parameters:
    label: file
    type: str
    value: rx_log.csv
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: fc
    dev_args: driver=hackrf
    samp_rate: usrp_rate
    type: fc32
    vga: '20'
  states: {}
- name: timestamp
  id: parameter
  parameters:
    label: filename
    type: str
    value: timestampsRx.txt
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: r1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: stream_tagged
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: stream_tagged
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: r1
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49201
    bind: 'True'
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [analog_agc_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [analog_agc_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_repack_bits_bb_1_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', epy_block_2, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_crc32_bb_0_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_diff_decoder_bb_0, '0', virtual_sink_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_fll_band_edge_cc_0, '0', virtual_sink_0, '0']
- [digital_map_bb_0, '0', blocks_uchar_to_float_0_0, '0']
- [digital_map_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [epy_block_0, pdu_out, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_2, '0', digital_constellation_decoder_cb_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, virtual_sink_1, '0']
- [soapy_hackrf_source_0, '0', analog_agc_xx_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_1, '0', blocks_message_debug_0, print]
- [virtual_source_1, '0', epy_block_0, pdu_in]
- [virtual_source_2, '0', digital_map_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
