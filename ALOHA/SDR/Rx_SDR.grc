options:
  parameters:
    author: venka
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: RxA
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: bw
  id: variable
  parameters:
    value: (1+excess_bw)*(samp_rate//sps)
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: fc
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: freq_range
  id: variable_qtgui_range
  parameters:
    start: 70e3
    step: 10e3
    stop: 130e3
    value: 100e3
  states: {}
- name: low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: (bw//2)+5e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: packet_size
  id: variable
  parameters:
    value: '80'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0445'
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: samp_rate/usrp_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0 + 0.0j, ]'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '32'
  states: {}
- name: user_id1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: user_id2
  id: variable
  parameters:
    value: '2'
  states: {}
- name: user_id3
  id: variable
  parameters:
    value: '3'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-80'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '44'
    improved_loop_filter: 'False'
    rolloff: excess_bw
    samps_per_sym: sps
    type: cc
    w: phase_bw
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_2_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python
      from gnuradio import gr
      import numpy as np
      import time
      import csv

      class iq_logger_with_timestamp(gr.sync_block):
          def __init__(self, iq_csv_filename="iq_samples.csv"):
              gr.sync_block.__init__(
                  self,
                  name="iq_logger_with_timestamp",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.iq_csv_filename = iq_csv_filename
              self.sample_count = 0

              # Initialize CSV with header (same pattern as Random_Packet_Generator)
              with open(self.iq_csv_filename, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'sample_index',
                      'timestamp',
                      'num_samples',
                      'i_values',
                      'q_values'
                  ])

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              # Timestamp with millisecond precision (matches Random_Packet_Generator style)
              timestamp = time.strftime('%Y-%m-%d %H:%M:%S') + \
                          f".{int((time.time() % 1) * 1000):03d}"

              num_samples = len(in0)

              # Split complex64 into separate I and Q lists
              i_values = in0.real.tolist()
              q_values = in0.imag.tolist()

              # Append row to CSV
              with open(self.iq_csv_filename, 'a', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      self.sample_count,
                      timestamp,
                      num_samples,
                      i_values,
                      q_values
                  ])

              self.sample_count += num_samples

              # Pass samples through unchanged
              out0[:] = in0
              return len(out0)

          def stop(self):
              print(f"[IQ Logger] Finished. Total samples logged: {self.sample_count}")
              return True
    iq_csv_filename: iq
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import csv
      import time
      import binascii

      class access_code_correlator(gr.sync_block):
          """
          Bitwise sliding-window access code correlator with CRC32 verification.

          TX packet wire format:
              [access_code : 4 B]              <- correlated against, consumed
              [seq_num     : 2 B big-endian]
              [user_id     : 2 B big-endian]
              [random data : (packet_size-16) B]
              [CRC32       : 4 B little-endian] <- over AC+seq+uid+random
              [filler      : 8 B]              <- flush bytes, discarded

          Parameters
          ----------
          packet_size : int   Total bytes from Random_Packet_Generator (default 56)
          threshold   : int   Min bit matches out of 32 to accept AC (default 28)
          log_file    : str   CSV output path
          """

          ACCESS_CODE_BYTES = [0xE1, 0x5A, 0xE8, 0x93]
          FILLER_LEN        = 4

          def __init__(self, packet_size=56, threshold=28,
                       log_file="rx_decoded_packets.csv"):

              gr.sync_block.__init__(self,
                  name="access_code_correlator",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8])

              self.message_port_register_out(pmt.intern('pdu_out'))

              self.packet_size = int(packet_size)
              self.threshold   = int(threshold)
              self.log_file    = log_file

              self.ac_bits = np.array(
                  [int(b) for byte in self.ACCESS_CODE_BYTES
                           for b in format(byte, '08b')],
                  dtype=np.uint8)
              self.ac_len = len(self.ac_bits)   # 32

              # After AC consumed: seq(2)+uid(2)+random(pkt-16)+CRC(4)+filler(4)
              self.post_ac_bits = (packet_size - 4) * 8

              # random payload length
              self.payload_len = packet_size - 16   # pkt - AC - hdr - CRC - filler

              self._buf          = np.empty(0, dtype=np.uint8)
              self._state        = 'SEARCH'
              self._collect_bits = []
              self._pkt_count    = 0

              with open(self.log_file, 'w', newline='') as f:
                  csv.writer(f).writerow([
                      'pkt_index', 'rx_time', 'user_id', 'seq_num',
                      'crc_ok', 'payload_hex', 'payload_len_bytes'
                  ])

          @staticmethod
          def _bits_to_bytes(bits):
              result = []
              for i in range(len(bits) // 8):
                  byte = 0
                  for b in bits[i*8: i*8+8]:
                      byte = (byte << 1) | int(b)
                  result.append(byte)
              return result

          def _process_packet(self, collect_bits):
              raw = self._bits_to_bytes(collect_bits)
              # raw layout: [seq(2)][uid(2)][random(payload_len)][CRC(4)][filler(4)]

              # Define your expected filler
              # EXPECTED_FILLER = [0xDE, 0xAD, 0xBE, 0xEF]
              # actual_filler = raw[-4:]

              # # Check if the filler matches
              # if actual_filler != EXPECTED_FILLER:
              #     # This was likely a false trigger in the middle of a packet
              #     return

              if len(raw) < 4 + self.payload_len + 4 + self.FILLER_LEN:
                  print(f"[AC_CORR] Too short ({len(raw)} B), discarding")
                  return

              seq_num  = (raw[0] << 8) | raw[1]
              user_id  = (raw[2] << 8) | raw[3]
              payload  = raw[4 : 4 + self.payload_len]
              crc_rx   = raw[4 + self.payload_len : 4 + self.payload_len + 4]
              # filler = raw[-4:]  — discarded

              # CRC was computed over: seq + uid + random
              body         = raw[:4 + self.payload_len]
              crc_expected = binascii.crc32(bytes(body)) & 0xFFFFFFFF
              # crc_actual   = int.from_bytes(crc_rx, byteorder='little')
              crc_actual = int.from_bytes(bytes(crc_rx), byteorder='little')
              crc_ok       = (crc_expected == crc_actual)
              print(f"[AC_CORR] CRC check: expected={crc_expected:#010x} actual={crc_actual:#010x} {'OK' if crc_ok else 'FAIL'}") 

              self._pkt_count += 1
              status = "OK" if crc_ok else "FAIL"
              print(
                  f"[AC_CORR PKT {self._pkt_count:04d}] "
                  f"user_id={user_id}  seq_num={seq_num:#06x}  "
                  f"CRC={status}  payload={len(payload)} B"
              )

              now     = time.time()
              rx_time = time.strftime('%Y-%m-%d %H:%M:%S', time.localtime(now)) \
                        + f".{int((now % 1)*1000):03d}"
              pay_hex = ' '.join(f'{b:02X}' for b in payload)

              with open(self.log_file, 'a', newline='') as f:
                  csv.writer(f).writerow([
                      self._pkt_count, rx_time, user_id, seq_num,
                      crc_ok, pay_hex, len(payload)
                  ])

              meta = pmt.make_dict()
              meta = pmt.dict_add(meta, pmt.intern('user_id'), pmt.from_long(user_id))
              meta = pmt.dict_add(meta, pmt.intern('seq_num'),  pmt.from_long(seq_num))
              meta = pmt.dict_add(meta, pmt.intern('crc_ok'),   pmt.from_bool(crc_ok))
              pdu  = pmt.cons(meta, pmt.init_u8vector(len(raw), raw))
              self.message_port_pub(pmt.intern('pdu_out'), pdu)

          def work(self, input_items, output_items):
              in0  = input_items[0]
              out0 = output_items[0]
              out0[:] = in0

              self._buf = np.concatenate([self._buf, in0])

              while True:
                  if self._state == 'SEARCH':
                      if len(self._buf) < self.ac_len:
                          break

                      n  = len(self._buf) - self.ac_len + 1
                      s  = self._buf.strides[0]
                      W  = np.lib.stride_tricks.as_strided(
                               self._buf, shape=(n, self.ac_len), strides=(s, s))
                      corrs = np.sum(W == self.ac_bits, axis=1)
                      hits  = np.where(corrs >= self.threshold)[0]

                      if len(hits) == 0:
                          self._buf = self._buf[-(self.ac_len - 1):]
                          break

                      idx = int(hits[0])
                      print(f"[AC_CORR] AC @ buf[{idx}] corr={int(corrs[idx])}/32")
                      self._buf          = self._buf[idx + self.ac_len:]
                      self._state        = 'COLLECT'
                      self._collect_bits = []

                  elif self._state == 'COLLECT':
                      still_need = self.post_ac_bits - len(self._collect_bits)

                      if len(self._buf) >= still_need:
                          self._collect_bits.extend(self._buf[:still_need].tolist())
                          self._buf  = self._buf[still_need:]
                          self._process_packet(self._collect_bits)
                          self._state = 'SEARCH'
                      else:
                          self._collect_bits.extend(self._buf.tolist())
                          self._buf = np.empty(0, dtype=np.uint8)
                          break

              return len(in0)
    log_file: rx_log
    packet_size: packet_size
    threshold: thresh
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_range
    decim: (int)(usrp_rate/samp_rate)
    samp_rate: usrp_rate
    taps: firdes.low_pass(1, 2000000, 20000, 5000)
    type: ccc
  states: {}
- name: iq
  id: parameter
  parameters:
    label: filename
    type: str
    value: iqRx.csv
  states: {}
- name: log_file1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: data_tx1.csv
  states: {}
- name: log_file2
  id: parameter
  parameters:
    label: File Name
    type: str
    value: data_tx2.csv
  states: {}
- name: log_file3
  id: parameter
  parameters:
    label: File Name
    type: str
    value: data_tx3.csv
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    comment: 0,2,1,2
    gui_hint: 0,2,1,2
    name: RX_Cos
    size: '1024'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    comment: 0,0,1,2
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,2
    name: RX_Sym
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    gui_hint: 1,0,1,2
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    style1: '4'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: 1,0,1,2
    grid: 'True'
    gui_hint: 1,2,1,2
    label1: ''
    name: Correlate input
    size: '2048'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.2'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: (samp_rate//sps)
    type: fir_filter_ccf
  states: {}
- name: rx_log
  id: parameter
  parameters:
    label: file
    type: str
    value: rx_log.csv
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: fc
    gain: '40'
    samp_rate: usrp_rate
    type: fc32
    vga: '50'
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: r1
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: r1
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_0_2, '0']
- [digital_constellation_decoder_cb_0, '0', virtual_sink_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', epy_block_2_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_time_sink_x_0, '0']
- [digital_map_bb_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_map_bb_0, '0', epy_block_3, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [epy_block_2_0, '0', digital_constellation_decoder_cb_0, '0']
- [epy_block_3, '0', blocks_null_sink_0, '0']
- [epy_block_3, pdu_out, blocks_message_debug_0, print]
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [root_raised_cosine_filter_0, '0', digital_fll_band_edge_cc_0, '0']
- [soapy_hackrf_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_2, '0', digital_diff_decoder_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
