options:
  parameters:
    author: venka
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: accessCode
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: bw
  id: variable
  parameters:
    value: (1+excess_bw)*(samp_rate//sps)
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: fc
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: (bw//2)+5e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: packet_size
  id: variable
  parameters:
    value: '80'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: samp_rate/usrp_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0 + 0.0j, ]'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '28'
  states: {}
- name: user_id1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: user_id2
  id: variable
  parameters:
    value: '2'
  states: {}
- name: user_id3
  id: variable
  parameters:
    value: '3'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_0_0_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_feedforward_agc_cc_0
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: '1024'
    reference: '1.0'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: 8*sps
    type: float
  states: {}
- name: blocks_repeat_0_0_0
  id: blocks_repeat
  parameters:
    interp: 8*sps
    type: float
  states: {}
- name: blocks_repeat_0_0_1
  id: blocks_repeat
  parameters:
    interp: 8*sps
    type: float
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2*math.pi *(100e3 / usrp_rate)
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_constellation_modulator_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0_0_1
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import collections

      class PDU_to_Timed_Byte_Stream(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='PDU to Timed Byte Stream',
                  in_sig=None,
                  out_sig=[np.uint8, np.uint8] # Port 0: Data, Port 1: Gate
              )
              self.message_port_register_in(pmt.intern("pdus"))
              self.set_msg_handler(pmt.intern("pdus"), self.handle_msg)
              
              self.byte_buffer = collections.deque()
              # Track the start of new packets for tagging
              self.packet_lengths = collections.deque() 
              self.bytes_left_in_packet = 0

          def handle_msg(self, msg):
              data = pmt.u8vector_elements(pmt.cdr(msg))
              p_len = len(data)
              # Store the data and the length of this specific packet
              for b in data:
                  self.byte_buffer.append(b)
              self.packet_lengths.append(p_len)

          def work(self, input_items, output_items):
              out_data = output_items[0]
              out_gate = output_items[1]
              n = len(out_data)

              for i in range(n):
                  if self.byte_buffer:
                      # Logic to detect the exact start of a burst
                      if self.bytes_left_in_packet == 0 and self.packet_lengths:
                          self.bytes_left_in_packet = self.packet_lengths.popleft()
                          
                          # Add the Stream Tag
                          key = pmt.intern("burst_start")
                          value = pmt.from_long(1)
                          # self.add_item_tag(0, self.nitems_written(0) + i, key, value)
                          self.add_item_tag(1, self.nitems_written(1) + i, key, value)
                      
                      out_data[i] = self.byte_buffer.popleft()
                      out_gate[i] = 1
                      # if i==0 or i==n-1:
                      #     print("gate activated at index", i)
                      #     print(n, self.bytes_left_in_packet)
                      
                      if self.bytes_left_in_packet > 0:
                          self.bytes_left_in_packet -= 1
                  else:
                      out_data[i] = 0
                      out_gate[i] = 0
                      self.bytes_left_in_packet = 0 # Reset just in case

              return n
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import collections

      class PDU_to_Timed_Byte_Stream(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='PDU to Timed Byte Stream',
                  in_sig=None,
                  out_sig=[np.uint8, np.uint8] # Port 0: Data, Port 1: Gate
              )
              self.message_port_register_in(pmt.intern("pdus"))
              self.set_msg_handler(pmt.intern("pdus"), self.handle_msg)
              
              self.byte_buffer = collections.deque()
              # Track the start of new packets for tagging
              self.packet_lengths = collections.deque() 
              self.bytes_left_in_packet = 0

          def handle_msg(self, msg):
              data = pmt.u8vector_elements(pmt.cdr(msg))
              p_len = len(data)
              # Store the data and the length of this specific packet
              for b in data:
                  self.byte_buffer.append(b)
              self.packet_lengths.append(p_len)

          def work(self, input_items, output_items):
              out_data = output_items[0]
              out_gate = output_items[1]
              n = len(out_data)

              for i in range(n):
                  if self.byte_buffer:
                      # Logic to detect the exact start of a burst
                      if self.bytes_left_in_packet == 0 and self.packet_lengths:
                          self.bytes_left_in_packet = self.packet_lengths.popleft()
                          
                          # Add the Stream Tag
                          key = pmt.intern("burst_start")
                          value = pmt.from_long(1)
                          # self.add_item_tag(0, self.nitems_written(0) + i, key, value)
                          self.add_item_tag(1, self.nitems_written(1) + i, key, value)
                      
                      out_data[i] = self.byte_buffer.popleft()
                      out_gate[i] = 1
                      # if i==0 or i==n-1:
                      #     print("gate activated at index", i)
                      #     print(n, self.bytes_left_in_packet)
                      
                      if self.bytes_left_in_packet > 0:
                          self.bytes_left_in_packet -= 1
                  else:
                      out_data[i] = 0
                      out_gate[i] = 0
                      self.bytes_left_in_packet = 0 # Reset just in case

              return n
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import collections

      class PDU_to_Timed_Byte_Stream(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='PDU to Timed Byte Stream',
                  in_sig=None,
                  out_sig=[np.uint8, np.uint8] # Port 0: Data, Port 1: Gate
              )
              self.message_port_register_in(pmt.intern("pdus"))
              self.set_msg_handler(pmt.intern("pdus"), self.handle_msg)
              
              self.byte_buffer = collections.deque()
              # Track the start of new packets for tagging
              self.packet_lengths = collections.deque() 
              self.bytes_left_in_packet = 0

          def handle_msg(self, msg):
              data = pmt.u8vector_elements(pmt.cdr(msg))
              p_len = len(data)
              # Store the data and the length of this specific packet
              for b in data:
                  self.byte_buffer.append(b)
              self.packet_lengths.append(p_len)

          def work(self, input_items, output_items):
              out_data = output_items[0]
              out_gate = output_items[1]
              n = len(out_data)

              for i in range(n):
                  if self.byte_buffer:
                      # Logic to detect the exact start of a burst
                      if self.bytes_left_in_packet == 0 and self.packet_lengths:
                          self.bytes_left_in_packet = self.packet_lengths.popleft()
                          
                          # Add the Stream Tag
                          key = pmt.intern("burst_start")
                          value = pmt.from_long(1)
                          # self.add_item_tag(0, self.nitems_written(0) + i, key, value)
                          self.add_item_tag(1, self.nitems_written(1) + i, key, value)
                      
                      out_data[i] = self.byte_buffer.popleft()
                      out_gate[i] = 1
                      # if i==0 or i==n-1:
                      #     print("gate activated at index", i)
                      #     print(n, self.bytes_left_in_packet)
                      
                      if self.bytes_left_in_packet > 0:
                          self.bytes_left_in_packet -= 1
                  else:
                      out_data[i] = 0
                      out_gate[i] = 0
                      self.bytes_left_in_packet = 0 # Reset just in case

              return n
  states: {}
- name: epy_block_2_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import random
      import time
      import threading
      import csv
      import binascii

      class Random_Packet_Generator(gr.basic_block):
          """
          Random Packet Generator with embedded userid and sequence number.

          Packet payload layout:
              [0:2]  – seq_num  : 2 bytes, big-endian uint16
              [2:4]  – user_id  : 2 bytes, big-endian uint16  (0–65535)
              [4:]   – random data : fills the rest up to packet_size bytes

          The PMT metadata dict carries:
              'packet_num' → seq_num  (used by Packet Header Generator block)
              'user_id'    → user_id  (informational)
          """

          def __init__(self,
                       mean_interval=0.1,
                       packet_size=100,
                       user_id=1,
                       log_file="transmitted_packets.csv", 
                       total_packets=10,
                       initial_delay=2.0): # 1. ADDED: initial_delay parameter

              gr.basic_block.__init__(self,
                  name="random_packet_generator",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_out(pmt.intern('pdu_out'))

              # ── Parameters ────────────────────────────────────────────────
              self.mean_interval = mean_interval
              self.packet_size   = packet_size
              self.user_id       = int(user_id) & 0xFFFF   # clamp to uint16
              self.log_file      = log_file
              self.total_packets = total_packets
              self.initial_delay = initial_delay           # 2. ADDED: store delay attribute

              self.packet_count  = 0

              # Header overhead: seq(2) + user_id(2) = 4 bytes
              if packet_size <= 4:
                  raise ValueError(
                      f"packet_size ({packet_size}) must be > 4 to fit the header"
                  )

              # ── Init CSV log ──────────────────────────────────────────────
              with open(self.log_file, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'packet_id', 'timestamp', 'user_id',
                      'wait_time_s', 'data_hex', 'data_bytes'
                  ])

              # ── Start generator thread ────────────────────────────────────
              self.thread = threading.Thread(target=self._generate_packets, daemon=True)
              self.thread.start()

          # ─────────────────────────────────────────────────────────────────
          def _build_payload(self, seq: int) -> list:
              access_code = [0xE1, 0x5A, 0xE8, 0x93]                    # 4 bytes
              filler      = [0xDE, 0xAD, 0xBE, 0xEF]                    # 4 bytes

              header = [
                  (seq >> 8) & 0xFF,
                  seq & 0xFF,
                  (self.user_id >> 8) & 0xFF,
                  self.user_id & 0xFF,
              ]                                                           # 4 bytes

              # Reserve space for access_code(4) + header(4) + CRC(4) + filler(4)
              payload_len = self.packet_size - len(access_code) - len(header) - 4 - len(filler)
              if payload_len < 0:
                  raise ValueError(
                      f"packet_size ({self.packet_size}) too small: need at least "
                      f"{len(access_code) + len(header) + 4 + len(filler)} bytes "
                      f"for fixed fields + CRC"
                  )
              random_bytes = [random.randint(0, 255) for _ in range(payload_len)]

              # CRC32 over header + random_bytes only (access_code and filler excluded)
              protected = header + random_bytes
              crc_val   = binascii.crc32(bytes(protected)) & 0xFFFFFFFF
              crc_bytes = list(crc_val.to_bytes(4, byteorder='little'))

              # Final layout: [access_code | header | random_bytes | CRC32 | filler]
              return access_code + protected + crc_bytes + filler * 2

          # ─────────────────────────────────────────────────────────────────
          def _generate_packets(self):
              seq = 0
              
              # 3. ADDED: Force a hard wait before starting the packet generation loop
              print(f"[Random_Packet_Generator TX{self.user_id}] Waiting {self.initial_delay}s for hardware warmup...")
              time.sleep(self.initial_delay)
              
              # Keep the random stagger so multiple TX blocks don't start at the exact same millisecond
              time.sleep(random.uniform(0, self.mean_interval))
              
              while self.packet_count < self.total_packets:
                  wait_time = random.expovariate(1.0 / self.mean_interval)
                  time.sleep(wait_time)

                  data = self._build_payload(seq)

                  # ── Build PMT metadata dict ───────────────────────────────
                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta,
                                      pmt.intern('packet_num'),
                                      pmt.from_long(seq))             # Packet Header Generator
                  meta = pmt.dict_add(meta,
                                      pmt.intern('user_id'),
                                      pmt.from_long(self.user_id))    # informational

                  # ── Publish PDU ───────────────────────────────────────────
                  pdu = pmt.cons(meta, pmt.init_u8vector(len(data), data))
                  self.message_port_pub(pmt.intern('pdu_out'), pdu)

                  self.packet_count += 1
                  seq = (seq + 1) & 0xFFFF    # 16-bit rollover

                  # ── CSV logging ───────────────────────────────────────────
                  timestamp = (time.strftime('%Y-%m-%d %H:%M:%S') +
                               f".{int((time.time() % 1) * 1000):03d}")
                  data_hex  = ' '.join(f'{b:02X}' for b in data)

                  with open(self.log_file, 'a', newline='') as f:
                      writer = csv.writer(f)
                      writer.writerow([
                          self.packet_count,
                          timestamp,
                          self.user_id,
                          f"{wait_time:.4f}",
                          data_hex,
                          list(data)
                      ])

                  print(f"[PKT {self.packet_count:03d}] user_id={self.user_id} "
                        f"seq={seq - 1 & 0xFFFF:#06x} "
                        f"after {wait_time:.3f}s | "
                        f"first 4B: {data_hex.split()[:4]}")
    initial_delay: '0'
    log_file: log_file2
    mean_interval: '0.4'
    packet_size: packet_size
    total_packets: '1000'
    user_id: user_id2
  states: {}
- name: epy_block_2_1_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import random
      import time
      import threading
      import csv
      import binascii

      class Random_Packet_Generator(gr.basic_block):
          """
          Random Packet Generator with embedded userid and sequence number.

          Packet payload layout:
              [0:2]  – seq_num  : 2 bytes, big-endian uint16
              [2:4]  – user_id  : 2 bytes, big-endian uint16  (0–65535)
              [4:]   – random data : fills the rest up to packet_size bytes

          The PMT metadata dict carries:
              'packet_num' → seq_num  (used by Packet Header Generator block)
              'user_id'    → user_id  (informational)
          """

          def __init__(self,
                       mean_interval=0.1,
                       packet_size=100,
                       user_id=1,
                       log_file="transmitted_packets.csv", 
                       total_packets=10,
                       initial_delay=2.0): # 1. ADDED: initial_delay parameter

              gr.basic_block.__init__(self,
                  name="random_packet_generator",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_out(pmt.intern('pdu_out'))

              # ── Parameters ────────────────────────────────────────────────
              self.mean_interval = mean_interval
              self.packet_size   = packet_size
              self.user_id       = int(user_id) & 0xFFFF   # clamp to uint16
              self.log_file      = log_file
              self.total_packets = total_packets
              self.initial_delay = initial_delay           # 2. ADDED: store delay attribute

              self.packet_count  = 0

              # Header overhead: seq(2) + user_id(2) = 4 bytes
              if packet_size <= 4:
                  raise ValueError(
                      f"packet_size ({packet_size}) must be > 4 to fit the header"
                  )

              # ── Init CSV log ──────────────────────────────────────────────
              with open(self.log_file, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'packet_id', 'timestamp', 'user_id',
                      'wait_time_s', 'data_hex', 'data_bytes'
                  ])

              # ── Start generator thread ────────────────────────────────────
              self.thread = threading.Thread(target=self._generate_packets, daemon=True)
              self.thread.start()

          # ─────────────────────────────────────────────────────────────────
          def _build_payload(self, seq: int) -> list:
              access_code = [0xE1, 0x5A, 0xE8, 0x93]                    # 4 bytes
              filler      = [0xDE, 0xAD, 0xBE, 0xEF]                    # 4 bytes

              header = [
                  (seq >> 8) & 0xFF,
                  seq & 0xFF,
                  (self.user_id >> 8) & 0xFF,
                  self.user_id & 0xFF,
              ]                                                           # 4 bytes

              # Reserve space for access_code(4) + header(4) + CRC(4) + filler(4)
              payload_len = self.packet_size - len(access_code) - len(header) - 4 - len(filler)
              if payload_len < 0:
                  raise ValueError(
                      f"packet_size ({self.packet_size}) too small: need at least "
                      f"{len(access_code) + len(header) + 4 + len(filler)} bytes "
                      f"for fixed fields + CRC"
                  )
              random_bytes = [random.randint(0, 255) for _ in range(payload_len)]

              # CRC32 over header + random_bytes only (access_code and filler excluded)
              protected = header + random_bytes
              crc_val   = binascii.crc32(bytes(protected)) & 0xFFFFFFFF
              crc_bytes = list(crc_val.to_bytes(4, byteorder='little'))

              # Final layout: [access_code | header | random_bytes | CRC32 | filler]
              return access_code + protected + crc_bytes + filler * 2

          # ─────────────────────────────────────────────────────────────────
          def _generate_packets(self):
              seq = 0
              
              # 3. ADDED: Force a hard wait before starting the packet generation loop
              print(f"[Random_Packet_Generator TX{self.user_id}] Waiting {self.initial_delay}s for hardware warmup...")
              time.sleep(self.initial_delay)
              
              # Keep the random stagger so multiple TX blocks don't start at the exact same millisecond
              time.sleep(random.uniform(0, self.mean_interval))
              
              while self.packet_count < self.total_packets:
                  wait_time = random.expovariate(1.0 / self.mean_interval)
                  time.sleep(wait_time)

                  data = self._build_payload(seq)

                  # ── Build PMT metadata dict ───────────────────────────────
                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta,
                                      pmt.intern('packet_num'),
                                      pmt.from_long(seq))             # Packet Header Generator
                  meta = pmt.dict_add(meta,
                                      pmt.intern('user_id'),
                                      pmt.from_long(self.user_id))    # informational

                  # ── Publish PDU ───────────────────────────────────────────
                  pdu = pmt.cons(meta, pmt.init_u8vector(len(data), data))
                  self.message_port_pub(pmt.intern('pdu_out'), pdu)

                  self.packet_count += 1
                  seq = (seq + 1) & 0xFFFF    # 16-bit rollover

                  # ── CSV logging ───────────────────────────────────────────
                  timestamp = (time.strftime('%Y-%m-%d %H:%M:%S') +
                               f".{int((time.time() % 1) * 1000):03d}")
                  data_hex  = ' '.join(f'{b:02X}' for b in data)

                  with open(self.log_file, 'a', newline='') as f:
                      writer = csv.writer(f)
                      writer.writerow([
                          self.packet_count,
                          timestamp,
                          self.user_id,
                          f"{wait_time:.4f}",
                          data_hex,
                          list(data)
                      ])

                  print(f"[PKT {self.packet_count:03d}] user_id={self.user_id} "
                        f"seq={seq - 1 & 0xFFFF:#06x} "
                        f"after {wait_time:.3f}s | "
                        f"first 4B: {data_hex.split()[:4]}")
    initial_delay: '0'
    log_file: log_file1
    mean_interval: '0.4'
    packet_size: packet_size
    total_packets: '1000'
    user_id: user_id1
  states: {}
- name: epy_block_2_1_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import random
      import time
      import threading
      import csv
      import binascii

      class Random_Packet_Generator(gr.basic_block):
          """
          Random Packet Generator with embedded userid and sequence number.

          Packet payload layout:
              [0:2]  – seq_num  : 2 bytes, big-endian uint16
              [2:4]  – user_id  : 2 bytes, big-endian uint16  (0–65535)
              [4:]   – random data : fills the rest up to packet_size bytes

          The PMT metadata dict carries:
              'packet_num' → seq_num  (used by Packet Header Generator block)
              'user_id'    → user_id  (informational)
          """

          def __init__(self,
                       mean_interval=0.1,
                       packet_size=100,
                       user_id=1,
                       log_file="transmitted_packets.csv", 
                       total_packets=10,
                       initial_delay=2.0): # 1. ADDED: initial_delay parameter

              gr.basic_block.__init__(self,
                  name="random_packet_generator",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_out(pmt.intern('pdu_out'))

              # ── Parameters ────────────────────────────────────────────────
              self.mean_interval = mean_interval
              self.packet_size   = packet_size
              self.user_id       = int(user_id) & 0xFFFF   # clamp to uint16
              self.log_file      = log_file
              self.total_packets = total_packets
              self.initial_delay = initial_delay           # 2. ADDED: store delay attribute

              self.packet_count  = 0

              # Header overhead: seq(2) + user_id(2) = 4 bytes
              if packet_size <= 4:
                  raise ValueError(
                      f"packet_size ({packet_size}) must be > 4 to fit the header"
                  )

              # ── Init CSV log ──────────────────────────────────────────────
              with open(self.log_file, 'w', newline='') as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      'packet_id', 'timestamp', 'user_id',
                      'wait_time_s', 'data_hex', 'data_bytes'
                  ])

              # ── Start generator thread ────────────────────────────────────
              self.thread = threading.Thread(target=self._generate_packets, daemon=True)
              self.thread.start()

          # ─────────────────────────────────────────────────────────────────
          def _build_payload(self, seq: int) -> list:
              access_code = [0xE1, 0x5A, 0xE8, 0x93]                    # 4 bytes
              filler      = [0xDE, 0xAD, 0xBE, 0xEF]                    # 4 bytes

              header = [
                  (seq >> 8) & 0xFF,
                  seq & 0xFF,
                  (self.user_id >> 8) & 0xFF,
                  self.user_id & 0xFF,
              ]                                                           # 4 bytes

              # Reserve space for access_code(4) + header(4) + CRC(4) + filler(4)
              payload_len = self.packet_size - len(access_code) - len(header) - 4 - len(filler)
              if payload_len < 0:
                  raise ValueError(
                      f"packet_size ({self.packet_size}) too small: need at least "
                      f"{len(access_code) + len(header) + 4 + len(filler)} bytes "
                      f"for fixed fields + CRC"
                  )
              random_bytes = [random.randint(0, 255) for _ in range(payload_len)]

              # CRC32 over header + random_bytes only (access_code and filler excluded)
              protected = header + random_bytes
              crc_val   = binascii.crc32(bytes(protected)) & 0xFFFFFFFF
              crc_bytes = list(crc_val.to_bytes(4, byteorder='little'))

              # Final layout: [access_code | header | random_bytes | CRC32 | filler]
              return access_code + protected + crc_bytes + filler * 2
       
          # ─────────────────────────────────────────────────────────────────
          def _generate_packets(self):
              seq = 0
              
              # 3. ADDED: Force a hard wait before starting the packet generation loop
              print(f"[Random_Packet_Generator TX{self.user_id}] Waiting {self.initial_delay}s for hardware warmup...")
              time.sleep(self.initial_delay)
              
              # Keep the random stagger so multiple TX blocks don't start at the exact same millisecond
              time.sleep(random.uniform(0, self.mean_interval))
              
              while self.packet_count < self.total_packets:
                  wait_time = random.expovariate(1.0 / self.mean_interval)
                  time.sleep(wait_time)

                  data = self._build_payload(seq)

                  # ── Build PMT metadata dict ───────────────────────────────
                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta,
                                      pmt.intern('packet_num'),
                                      pmt.from_long(seq))             # Packet Header Generator
                  meta = pmt.dict_add(meta,
                                      pmt.intern('user_id'),
                                      pmt.from_long(self.user_id))    # informational

                  # ── Publish PDU ───────────────────────────────────────────
                  pdu = pmt.cons(meta, pmt.init_u8vector(len(data), data))
                  self.message_port_pub(pmt.intern('pdu_out'), pdu)

                  self.packet_count += 1
                  seq = (seq + 1) & 0xFFFF    # 16-bit rollover

                  # ── CSV logging ───────────────────────────────────────────
                  timestamp = (time.strftime('%Y-%m-%d %H:%M:%S') +
                               f".{int((time.time() % 1) * 1000):03d}")
                  data_hex  = ' '.join(f'{b:02X}' for b in data)

                  with open(self.log_file, 'a', newline='') as f:
                      writer = csv.writer(f)
                      writer.writerow([
                          self.packet_count,
                          timestamp,
                          self.user_id,
                          f"{wait_time:.4f}",
                          data_hex,
                          list(data)
                      ])

                  print(f"[PKT {self.packet_count:03d}] user_id={self.user_id} "
                        f"seq={seq - 1 & 0xFFFF:#06x} "
                        f"after {wait_time:.3f}s | "
                        f"first 4B: {data_hex.split()[:4]}")
    initial_delay: '0'
    log_file: log_file3
    mean_interval: '0.4'
    packet_size: packet_size
    total_packets: '1000'
    user_id: user_id3
  states: {}
- name: fft_filter_xxx_0_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0_0_0_1
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: log_file1
  id: parameter
  parameters:
    label: File Name
    type: str
    value: data_tx1.csv
  states: {}
- name: log_file2
  id: parameter
  parameters:
    label: File Name
    type: str
    value: data_tx2.csv
  states: {}
- name: log_file3
  id: parameter
  parameters:
    label: File Name
    type: str
    value: data_tx3.csv
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 1.0 / ( usrp_rate / samp_rate )
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    size: '10240'
    srate: usrp_rate
    stemplot: 'True'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: fc
    samp_rate: usrp_rate
    type: fc32
    vga: '40'
  states: {}
- name: virtual_sink_0_1_0_1_0
  id: virtual_sink
  parameters:
    stream_id: sig1
  states: {}
- name: virtual_sink_0_1_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: sig2
  states: {}
- name: virtual_sink_0_1_0_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: sig3
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: sig1
  states: {}
- name: virtual_source_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: sig2
  states: {}
- name: virtual_source_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: sig3
  states: {}

connections:
- [analog_const_source_x_0_0, '0', blocks_float_to_complex_0_0, '1']
- [analog_const_source_x_0_0_0, '0', blocks_float_to_complex_0_0_0, '1']
- [analog_const_source_x_0_0_1, '0', blocks_float_to_complex_0_0_1, '1']
- [analog_feedforward_agc_cc_0, '0', mmse_resampler_xx_0, '0']
- [blocks_add_xx_0, '0', analog_feedforward_agc_cc_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_float_to_complex_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_float_to_complex_0_0_1, '0', blocks_multiply_xx_0_0_1, '1']
- [blocks_multiply_xx_0_0, '0', fft_filter_xxx_0_0_0_0, '0']
- [blocks_multiply_xx_0_0_0, '0', fft_filter_xxx_0_0_0_0_0, '0']
- [blocks_multiply_xx_0_0_1, '0', fft_filter_xxx_0_0_0_0_1, '0']
- [blocks_repeat_0_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_repeat_0_0_0, '0', blocks_float_to_complex_0_0_0, '0']
- [blocks_repeat_0_0_1, '0', blocks_float_to_complex_0_0_1, '0']
- [blocks_rotator_cc_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_repeat_0_0, '0']
- [blocks_uchar_to_float_0_0_1, '0', blocks_repeat_0_0_1, '0']
- [blocks_uchar_to_float_0_1, '0', blocks_repeat_0_0_0, '0']
- [digital_constellation_modulator_0_0_0, '0', blocks_multiply_xx_0_0, '0']
- [digital_constellation_modulator_0_0_0_0, '0', blocks_multiply_xx_0_0_0, '0']
- [digital_constellation_modulator_0_0_0_1, '0', blocks_multiply_xx_0_0_1, '0']
- [epy_block_0_0, '0', digital_constellation_modulator_0_0_0, '0']
- [epy_block_0_0, '1', blocks_uchar_to_float_0_0, '0']
- [epy_block_0_0_0, '0', digital_constellation_modulator_0_0_0_1, '0']
- [epy_block_0_0_0, '1', blocks_uchar_to_float_0_0_1, '0']
- [epy_block_0_1, '0', digital_constellation_modulator_0_0_0_0, '0']
- [epy_block_0_1, '1', blocks_uchar_to_float_0_1, '0']
- [epy_block_2_1, pdu_out, epy_block_0_0, pdus]
- [epy_block_2_1_0, pdu_out, epy_block_0_1, pdus]
- [epy_block_2_1_1, pdu_out, epy_block_0_0_0, pdus]
- [fft_filter_xxx_0_0_0_0, '0', virtual_sink_0_1_0_1_0_0, '0']
- [fft_filter_xxx_0_0_0_0_0, '0', virtual_sink_0_1_0_1_0, '0']
- [fft_filter_xxx_0_0_0_0_1, '0', virtual_sink_0_1_0_1_0_0_0, '0']
- [mmse_resampler_xx_0, '0', blocks_rotator_cc_0, '0']
- [mmse_resampler_xx_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_1_0_0, '0', blocks_add_xx_0, '0']
- [virtual_source_1_0_0_0, '0', blocks_add_xx_0, '1']
- [virtual_source_1_0_0_0_0, '0', blocks_add_xx_0, '2']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
